fini
/cle

/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15


C***********************************************************************
C*** PARAMETERS
C***********************************************************************
k_complete=0		! 1: COMPLETE RUN INCLUDING LINEARIZED STRESS PLOT, OTHERWISE STOP BEFORE

r_tank=0.50		! TANK OUTER RADIUS
r_pipe=0.10		! PIPE OUTER RADIUS

l_tank=0.50		! MODELED STRAIGHT LENGTH OF TANK
l_pipe=0.50		! MODELED STRAIGHT LENGTH OF PIPE

r_fillet=0.10		! RADIUS OF FILLET BETWEEN PIPE AND TANK

t_wall=0.05		! PRESSURE VESSEL WALL THICKNESS

r_spherical_end=r_tank-(r_pipe+r_fillet)	! IMPLIED RADIUS OF END OF TANK (DO NOT EDIT)

E=2e11			! ELASTIC MODULUS
nu=0.3			! POISSON'S

P_internal=100*101000	! INTERNAL PRESSURE


C***********************************************************************
C*** GEOMETRY
C***********************************************************************
/prep7

wpcs,-1,0				! STRAIGHT PORTION OF TANK WALL
wpof,r_tank-t_wall
rect,,t_wall,,l_tank

wpof,-(r_spherical_end-t_wall),l_tank	! SPHERICAL END OF TANK
cswp,11,1
pcirc,r_spherical_end-t_wall,r_spherical_end,0,90

wpof,,r_spherical_end+r_fillet		! FILLET BETWEEN TANK AND PIPE
cswp,12,1
pcirc,r_fillet,r_fillet+t_wall,-90,-180

wpof,-(r_fillet+t_wall)			! STRAIGHT PORTION OF PIPE
rect,,t_wall,,l_pipe

numm,kp					! MERGE COICIDENT KEYPOINTS TO JOIN BODIES

/psy,csys,1
aplo

wpst,,,,,,,,0


C***********************************************************************
C*** ATTRIBUTES, MESH
C***********************************************************************
et,1,183,,,1				! MESH ATTRIBUTES
mp,ex,1,E
mp,nuxy,1,nu

esiz,t_wall/3				! MESH
mshk,1
ames,all


C***********************************************************************
C*** BCs
C***********************************************************************
csys				! AXIAL CONSTRAINTS ON TANK WALL
*get,ymin,kp,,mnloc,y
*get,ymax,kp,,mxloc,y
nsel,s,loc,y
d,all,uy

nsel,s,loc,y,ymax		! COUPLE UY AT END OF PIPE
cp,1,uy,all

csys				! INTERNAL PRESSURE
ksel,s,loc,x,r_tank-t_wall
ksel,a,loc,x,r_pipe-t_wall
csys,11
ksel,a,loc,x,r_spherical_end-t_wall
csys,12
ksel,a,loc,x,r_fillet+t_wall
lslk,s,1
nsll,s,1
sf,all,pres,P_internal

alls

/vie,1,1,2,3			! IMAGE OF MESH
/exp,27,axis,,,10
eplo
/wait,1.5

/vie				! IMAGE OF APPLIED BOUNDARY CONDITIONS AND PRESSURE LOAD
/exp
/pbc,u,1
/pbc,cp,1
/psf,pres,,2
eplo
/wait,1.5


C***********************************************************************
C*** SOLVE
C***********************************************************************
/solu
alls
solv
fini


C***********************************************************************
C***********************************************************************
C*** POST PROCESS
C***********************************************************************
C***********************************************************************
/post1
/dsc,1,1
plns,s,eqv				! PLOT EQUIVALENT STRESS
/wait,1.5

*get,seqvmax,plnsol,,max		! IDENTIFY NODE HAVING MAX EQUIV STRESS
nsel,s,s,eqv,seqvmax
nd2=ndnext(0)
csys,12					! IDENTIFY NODE ON OPPOSITE SIDE OF WALL
alls
nd1=node(nx(nd2)+t_wall,ny(nd2),0)

/edg,1,1

csys					! CLOSE UP OF EQUIVALENT STRESS
/foc,1,(nx(nd1)+nx(nd2))/2,(ny(nd1)+ny(nd2))/2
/dist,1,1.5*r_fillet
plns,s,eqv
/wait,1.5

rsys,12					! CLOSE UP OF SY IN CSYS12
plns,s,y
/wait,1.5

/edge
/pbc,path,,1
/col,path,red



C***********************************************************************
C*** PERFORM STRESS LINEARIZATION STEPS IF k_complete=1
C***********************************************************************
*if,k_complete,eq,1,then

path,p,2				! CREATE PATH BETWEEN NODES
ppath,1,nd1
ppath,2,nd2


C***********************************************************************
C*** IMAGE SHOWING BOTH LINEARIZED STRESS PLOT AND PATH ON STRESS CONTOUR
C*** IN A SINGLE IMAGE
C***********************************************************************

/win,1,top				! CREATE LINEARIZED STRESS PLOT
plsect,s,y,r_fillet+t_wall/2

rsys,12					! IMAGE SHOWING PATH ON STRESS CONTOUR
/pbc,path,,1
/col,path,red
/vie,1,1,2,3
/exp,27,axis,,,10

/noe
/win,1,bot
pdef,uy,u,y
/edge
plns,s,y

/era
/win,1,full

*endif


/eof










































finish		! LEAVE PROCESSOR
/clear		! CLEAR THE DATABASE


C********************************
C*** ESTABLISH VIEW SETTINGS
C********************************
/vie,1,2,1,3	! VIEWING DIRECTION
/eshape,1		! SHOW PLATE THICKNESS IN PLOTS


C********************************
C*** PARAMETERS (MKS UNITS)
C********************************
l=1.00		! BAR LENGTH (m)
h=0.10		! BAR HEIGHT (m)
t=0.05		! BAR THICKNESS (m)

r=0.35*h	! RADIUS OF HOLE IN BAR (m)
x_hole=l/4	! X COORDINATE OF HOLE (m)

esz=r/4		! ELEMENT SIZE (m)

E=2e11		! ELASTIC MODULUS (N/m^2)
nu=0.3		! POISSON'S RATIO

F_tip=-100	! FORCE APPLIED TO TIP (N)


/title,CANILEVER BAR WITH HOLE AND TIP LOAD


C********************************
C*** CREATE GEOMETRY
C********************************
/prep7			! ENTER THE PREPROCESSOR

rectng,,l,-h/2,h/2	! CREATE A BAR WITHOUT A HOLE (AREA #1)
wpof,x_hole		! POSITION WORKPLANE AT HOLE LOCATION
pcirc,r			! CREATE CIRCLE AT WORKPLANE (AREA #2)
asba,1,2		! BOOLEAN: SUBTRACT AREA #2 FROM AREA #1

aplot


C********************************
C*** DEFINE ATTRIBUTES, MESH
C********************************
et,1,183,0,,3	! ELEMENT TYPE #1: PLANE183, PLANE STRESS w/THICKNESS OPTION
r,1,t		! REAL CONSTANT SET #1: BAR THICKNESS
mp,ex,1,E	! MATERIAL PROPERTY #1: ELASTIC MODULUS
mp,nuxy,1,nu	! MATERIAL PROPERTY #1: POISSON'S

esize,esz	! DECLARE ELEMENT SIZE FOR MESHING

amesh,all	! MESH ALL SELECTED AREAS


C********************************
C*** BOUNDARY CONDITIONS
C********************************
nsel,s,loc,x,0		! SELECT NODES AT x=0
d,all,all		! CONSTRAIN ALL AVAILABLE DOFs AT ALL SELECTED NODES

allsel			! SELECT ALL ENTITIES IN MODEL
f,node(l,h/2,0),fy,F_tip	! APPLY FORCE IN Y DIRECTION AT NODE AT (x,y,z)=(l,h/2,0)

finish			! LEAVE THE PREPROCESSOR


C********************************
C*** SOLVE
C********************************
/solu			! ENTER THE SOLUTION PROCESSOR
allsel			! ENSURE ENTIRE MODEL IS SELECTED
save			! SAVE THE DATABASE
solve			! SOLVE
finish			! LEAVE THE SOLUTION PROCESSOR


C********************************
C*** POST PROCESS
C********************************
/post1			! ENTER THE GENERAL POST PROCESSOR
/pbc,u,,1		! DISPLAY IMPOSED CONSTRAINTS
/pbc,f,,1		! DISPLAY IMPOSED FORCES


C***********************************************************************
C*** ANNOTATION ON PLOT: SCREEN (X,Y) COORDINATES FOLLOWED BY TEXT
C*** NOTE FORCED PARAMETRIC SUBSTITUTION (%%) TO DISPLAY PARAMETERS
C*** IN THE ANNOTATION
C***********************************************************************
/tlabel,-0.25,0.90,BAR DIMENSIONS: %l% X %h% X %t% m
/tlabel,-0.25,0.85,   HOLE RADIUS = %r% m
/tlabel,-0.25,0.80,   HOLE X LOCATION = %x_hole% m
/tlabel,-0.25,0.75,   TIP LOAD = %f_tip% N


C********************************
C*** CREATE ANNOTATED PLOT
C********************************
plnsol,s,x		! CONTOUR PLOT OF X COMPONENT OF STRESS









	
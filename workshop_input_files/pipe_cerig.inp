fini
/cle

/fil,pipe_cerig

/vie,1,1,1,50
/pnu,type,1
/num,1
/tri,lbot
!/psy,dot,10

/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  


C******************************
C*** PARAMETERS
C******************************
pi=acos(-1)

l=2		! PIPE LENGTH
r1=0.10		! PIPE INNER RADIUS
r2=0.12		! PIPE OUTER RADIUS

esz=(r2-r1)/1.1	! ELEMENT SIZE
div_z=20

E=2e11/3	! ELASTIC MODULUS
nu=0.3		! POISSON'S RATIO

x_remote=0	! "REMOTE POINT" LOCATION
y_remote=0
z_remote=l


C******************************
C*** PIPE MODEL
C******************************
/prep7

etcon,set

cyli,r1,r2,0,l,0,90	! PIPE GEOMETRY
cyli,r1,r2,0,l,90,180
cyli,r1,r2,0,l,180,270
cyli,r1,r2,0,l,270,360
numm,kp

et,1,185			! PIPE ATTRIBUTES
mp,ex,1,E
mp,nuxy,1,nu

esiz,esz
lsel,u,loc,z
lsel,u,loc,z,l
lesi,all,,,div_z
vmes,all			! PIPE MESH


C******************************
C*** CERIG MASTER NODE & MASS21 ELEMENT
C******************************

alls		! HIGHEST NODE # IN MODEL
*get,nmax,node,,num,max

n,nmax+1,x_remote,y_remote,z_remote	! CREATE NEW (CERIG MASTER) NODE

et,2,21
r,2,1,1,1,1,1,1
type,2
real,2
e,nmax+1


C******************************
C*** BOUNDARY CONDITIONS
C******************************

nsel,s,loc,z			! BEAM CONSTRAINTS
d,all,ux
d,all,uy
d,all,uz


C******************************
C*** LOAD STEP OPTIONS
C******************************
pred,off	! TURN OFF PREDICTOR (DESTABILIZES, PREVENT CONVERGENCE)

nlge,on		! ACTIVATE NONLINEAR GEOMETRY EFFECTS

outr,all,all	! SAVE RESULTS FOR EACH SUBSTEP

/gty,1,node,1	! DISPLAY MODEL (ELEMENTS AND NODES)
/gty,1,volu,0
/gty,1,area,0
/gty,1,line,0
/gty,1,keyp,0
/gty,1,elem,1
esel,all
eplo
/use
nsel,s,node,,nmax+1

gplo



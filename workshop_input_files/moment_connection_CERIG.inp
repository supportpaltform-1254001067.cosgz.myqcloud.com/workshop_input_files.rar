
fini
/cle

/file,moment_connection
/sys,del moment_connection*.png
/title,CERIG Moment Connection

/vup,1,z
/vie,1,3,2,1
/esha,1
/pnu,mat,1
/num,1
  
/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  


C*****************************************************
C*** PARAMETERS
C*****************************************************
k_complete=0		! 1: COMPLETE RUN, OTHERWISE LEAVE OFF WHERE CLASS BEGINS

l_rod=0.5		! ROD LENGTH
r_rod=0.025		! ROD RADIUS

a_plate=0.75		! PLATE EDGE LENGTH
t_plate=0.010		! PLATE THICKNESS

r_bond=1.5*r_rod	! ROD/PLATE BOND REGION RADIUS

esz1=0.75*r_rod		! MESH SIZE IN/ADJACENT TO BOND REGION
esz2=2.5*esz1		! MESH SIZE ELSEWHERE
div_t=2			! DIVISIONS THROUGH PLATE THICKNESS

E=2e11			! ELASTIC MODULUS
nu=0.3			! POISSON'S

fy_tip=1000		! ROD TIP LOAD IN Y DIRECTION


C*****************************************************
C*** GEOMETRY
C*****************************************************
/prep7

k,1				! ROD LINE
k,2,,,l_rod
l,1,2
latt,1,1,1,,,,1

rect,,a_plate/2,,a_plate/2	! PLATE TOP SURFACE
pcirc,,r_bond,0,90
aovl,all
csys,1
agen,4,all,,,0,90
numm,kp

alls
gplo


C*****************************************************
C*** ATTRIBUTES, MESH
C*****************************************************
etcon,set

et,1,188		! ROD ATTTRIBUTES (BEAM188)
mp,ex,1,E
mp,nuxy,1,nu
sectype,1,beam,csolid
secdata,r_rod

et,2,185		! PLATE ATTRIBUTES (SOLID185)
mp,ex,2,E
mp,nuxy,2,nu
sectype,2,shell

et,200,200,6		! MESH SEGMENT

csys,1			! MESH TOP SURFACE OF PLATE (BOND REGION)
ksel,s,loc,x,0,r_bond
lslk,s,1
asll,s,1
aesi,all,esz1
kesi,all,esz1
mshk,2
ames,all

asel,inve		! MESH REST OF TOP SURFACE OF PLATE
esiz,esz2
ames,all

exto,esiz,div_t		! EXTRUDE PLATE TOP SURFACE MESH INTO MESHED VOLUMES
asel,s,loc,z
type,1 $mat,1
vext,all,,,0,0,-t_plate

lsel,s,mat,,1		! MESH ROD
lmes,all

alls
eplo


C*****************************************************
C*** BC's, LOADS
C*****************************************************
alls			! FIX PERIMETER OF PLATE
asel,s,ext
asel,u,loc,z
asel,u,loc,z,-t_plate
da,all,ux
da,all,uy
da,all,uz

alls			! APPLY FORCE AT TOP OF BEAM
fk,2,fy,fy_tip
sbctr

alls
/pbc,all,,1
eplo
/wait,2.5
/foc,1,0,0,0
/dist,1,0.05
lplo
/aut


*if,k_complete,eq,1,then

C*****************************************************
C*** MOMENT CONNECTION
C*****************************************************
ksel,s,kp,,1		! MASTER NODE AT BOTTOM OF ROD
nslk
nd_master=ndnext(0)

csys,1			! PLATE BOND REGION SLAVE NODES
nsel,s,loc,x,0,r_bond
nsel,r,loc,z

cerig,nd_master,all,uxyz	! CREATE RIGID REGION MOMENT CONNECTION

fini


C*****************************************************
C*** SOLVE
C*****************************************************
/solu
alls
save
solv
fini


C*****************************************************
C*** POST PROCESS
C*****************************************************
/post1

/pbc,u,,1
/pbc,f,,1
/pbc,ce,,1
/hbc,1,1
/vsc,1,2
/tri,rbot
/edg,1,1
plns,u,z
/sho,png $plns,u,z $/sho,close $/wait,1.5


/foc,1,0,0,0
/dist,1,0.05
/hbc,1,0
plns,u,z
/sho,png $plns,u,z $/sho,close $/wait,1.5

*endif































fini
/cle

/fil,fsum
/sys,del fsum*.png
wpst,0.025

/vie,1,1,1,1
!/dsc,1,1

/title,REACTION, FSUM, SURFACE AND PATH 

C*********************************************
C*** PARAMETERS
C*********************************************
k_complete=0

x1=0.100		! DISTANCE TO VERTICAL STRUT
x2=0.150		! TOTAL LENGTH

y1=0.050		! SEPERATION BETWEEN UPPER AND LOWER LEGS

z1=0.025		! MEMBER WIDTH

t=0.010			! MEMBER THICKNESS

esz=t/2			! MESH SIZE

E=2e11			! ELASTIC MODULUS
nu=0.3			! POISSON'S

f_tip=-2500		! TIP LOAD


blah = 2.3e8*(14.5/101000)
blah=3e6*t*z1


C*********************************************
C*** GEOMETRY
C*********************************************
/prep7

wpcs,-1,0			! UPPER LEG (SUBDIVIED ALONG LENGTH)
bloc,,x1/2,-t/2,t/2,-z1/2,z1/2
bloc,x1/2,x2,-t/2,t/2,-z1/2,z1/2

wpcs,-1,0			! LOWER LEG
wpof,,-y1
bloc,,x1+t/2,-t/2,t/2,-z1/2,z1/2

wpcs,-1,0			! VERTICAL STRUT
wpof,x1,-y1
bloc,-t/2,t/2,t/2,y1-t/2,-z1/2,z1/2


vglu,all			! BOOLEAN GLUE

vplo


C*********************************************
C*** ATTRIBUTES, MESH
C*********************************************
et,1,185,,2			! ATTRIBUTES
mp,ex,1,E
mp,nuxy,1,nu

esiz,esz			! MESHING
vswe,all

eplo


C*********************************************
C*** BCs
C*********************************************
nsel,s,loc,x			! CONSTRAIN AT X=0
d,all,all

nsel,s,loc,x,x2			! TIP LOAD
nsel,r,loc,y,t/2
cp,1,uy,all
f,ndnext(0),fy,f_tip

fini


C*********************************************
C*** SOLVE
C*********************************************
/solu
alls
save
solv
fini

wpcs,-1,0


C*********************************************
C*** POST PROCESS
C*********************************************
/post1
/pbc,u,,1
/pbc,cp,,1
/pbc,f,,1
/vsc,1,3
wpst,,,,,,,,0
/ann,dele
/tla,-0.35,0.90,        X COMPONENT STRESS
/tla,-0.35,0.85,(BOUNDARY CONDITIONS AND LOADS SHOWN)
plns,s,x,2
/sho,png $plns,s,x,2 $/sho,close $/wait,1.5
/vsc,1,1
/ann,dele
/pbc,all


*if,k_complete,eq,1,then

asel,s,loc,y,-t/2,t/2	! REACTION, TOP LEG
asel,r,loc,x
nsla,s,1
prrf
fsum
*get,FY_reaction,fsum,,item,fy

/pbc,all
/pbc,rfor,,1
esel,all
/ann,dele
/tla,-0.50,0.90,NET VERTICAL REACTION @ TOP LEG SUPPORT = %FY_reaction% N
pldi,2
/sho,png $pldi,2 $/sho,close $/wait,1.5


vsel,s,loc,y,-t/2,t/2	! FSUM HALFWAY ALONG LENGTH OF TOP LEG
vsel,r,loc,x,0,x1/2
alls,belo,volu
nsel,r,loc,x,x1/2
fsum
*get,FY_midspan,fsum,,item,fy	! GET RESULTS OF FSUM AS PARAMETER "FY_midspan"
ksel,all
lsel,all
/pbc,all
/pbc,nfor,,1
/gtyp,,node,0
/gtyp,,elem,1
/gtyp,,keyp,0
/gtyp,,line,1
/gtyp,,area,0
/gtyp,,volu,0
/gtyp,,grph,0
/gcmd,,plns,s,x
/ann,dele
/tla,-0.50,0.90,NET VERTICAL FSUM AT CUT IN TOP LEG SUPPORT = %FY_midspan% N
gplo
/sho,png $gplo $/sho,close $/wait,1.5


wpcs,-1,0			! SURFACE INTEGRAL SXY SOMEWHERE ALONG LENGTH OF TOP LEG
wpof,x1/2			! POSITION/ORIENT WORKPLANE FOR SURFACE CREATION
wpro,,,90
csys				! SELECT UPPER LEG ELEMENTS
vsel,s,loc,y,-t/2,t/2
alls,belo,volu
sucr,s,cplane			! CREATE SURFACE CUTTING THROUGH SELECTED UPPER LEG ELEMENTS
sumap,,sxy			! MAP SXY ONTO SURFACE
sueval,intg_sxy,sxy,intg	! "intg_sxy" = SURFACE INTEGRAL SXY OVER SURFACE
alls				! CONTOUR SXY ON SURFACE
/pbc,all
/ann,dele
/tla,-0.25,0.90,INTEGRAL SXY*DA ON SURFACE = %intg_sxy% N
suplot,,sxy,1
/sho,png $suplot,,sxy,1 $/sho,close $/wait,1.5

alls			! t * LINE INTEGRAL SXY SOMEWHERE ALONG LENGTH OF TOP LEG
path,p,2		! PATH "P" USES 2 POINTS		
ppath,1,,x1/2,t/2,z1/2	! POINT 1 LOCATION
ppath,2,,x1/2,t/2,-z1/2	! POINT 2 LOCATION
pdef,sxy,s,xy		! MAP SXY ONTO PATH
/pbc,all		! DISPLAY PATH GEOMETRY
/pbc,path,,1
/col,path,red
/ann,dele
/tla,-0.10,0.90,PATH FOR SXY INTEGRAL
eplo
/sho,png $eplo $/sho,close $/wait,1.5

pcalc,intg,intg_sxy,sxy,s,t	! INTEGRAL SXY ALONG PATH TIMES THICKNESS t

/ann,dele			! PLOT VARIATION OF SXY ALONG PATH
/tla,-0.10,0.90,VARIATION OF SXY ALONG PATH
/tla,-0.35,0.80,INTEGRAL SXY ALONG PATH TIMES t = %intg_sxy% N
plpa,sxy
/sho,png $plpa,sxy $/sho,close $/wait,1.5

*endif

/eof

csys
asel,s,loc,y,-t/2,t/2	! REACTION, TOP LEG
asel,r,loc,x
nsla,s,1

rsys
spoint,,0,0,0
fsum
spoint,,x2
fsum
rsys,4
fsum
























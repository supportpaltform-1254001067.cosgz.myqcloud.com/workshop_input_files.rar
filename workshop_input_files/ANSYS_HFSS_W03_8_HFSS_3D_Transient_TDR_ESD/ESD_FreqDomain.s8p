! Touchstone file from project Board_with_Connector
! Exported from HFSS 2014.0.0
# GHZ S MA R 50.000000
! Terminal data exported
! Port[1] = Connector1_s1_T1
! Port[2] = Connector1_s2_T1
! Port[3] = Port1_T1
! Port[4] = Port2_T1
! Port[5] = Port3_T1
! Port[6] = Port3_T2
! Port[7] = Port5_T1
! Port[8] = Port6_T1
! Worked out from all points (8-port):
!   12000 points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, 5.012 mHz to 5 GHz, reference 50 ohm
!   strongest paths, dB at 5.012 mHz, 5.012 Hz, 5.012 kHz, 5.012 MHz, 5 GHz:
!     S76: 0.0, 0.0, 0.0, 0.0, -1.5
!     S85: 0.0, 0.0, 0.0, 0.0, -1.5
!     S42: 0.0, 0.0, 0.0, 0.0, -2.1
!     S31: 0.0, 0.0, 0.0, 0.0, -2.8
!     S65: -86.2, -86.2, -86.2, -59.4, -16.5
!     S75: -86.9, -86.9, -86.9, -82.7, -18.3
!   lowest |S11| = -82.0 dB at 5.012 mHz (marker M1), VSWR 1.00, Z = 50 + j2.71e-10 ohm
!   |S11| at or under -10 dB: start of sweep to 4.509 GHz

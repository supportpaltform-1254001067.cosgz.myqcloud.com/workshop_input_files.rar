fini
/cle

/fil,snap_insertion

/sys,del snap_insertion*.png
/sys,del snap_insertion.rdb
/sys,del snap_insertion.ldhi
/sys,del snap_insertion.r0*

/vie,1,1,1,3

/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15 


C***************************************************************
C*** PARAMETERS
C***************************************************************
k_complete=0		! 1: RUN COMPLETE ANALYSIS, OTHERWISE USER FINISHES MODEL

ri=0.0250		! INNER RADIUS
t=0.0020		! THICKNESS OF BOTH MEMBERS

thta1=-25		! ANGLE OF PRONG TIP
thta2=-15		! ANGLE AT WHICH PRONG BARB ENDS
thta3=10		! ANGLE AT WHICH LONG SECTIONS OF RECEPTACAL ENDS
thta4=40		! ANGLE OF BASE OF PRONG

h_barb=t/2		! BARB HEIGHT

w=t			! WIDTH OF BOTH MEMBERS

rds=h_barb/5		! RADIUS AT BARB TIP AND RECEPTICLE CORNER

esz1=rds/2		! SMALL MESH SIZE AR RADIUSED CORNERS
esz2=t/3		! LARGER MESH SIZE ELSEWHERE

E=2e11/1000		! ELASTIC MODULUS
nu=0.2			! POISSON'S

fkn=0.005		! CONTACT NORMAL STIFFNESS FACTOR
fdmn=0	!0.1		! CONTACT NORMAL STABILIZATION DAMPING FACTOR

retract=h_barb/5	! PRONG RETRACTION AFTER FULL INSERTION

*afun,deg		! INITIAL Y COORDINATE OF PRONG
dy = abs((ri+t)*sin(thta1)) + abs((ri+t)*sin(thta3))

*dim,uy_prong,table,3,,,time	! TABLE: ENFORCED PRONG UY
uy_prong(1,1)=0,-dy,-dy+retract
uy_prong(1,0)=0,0.5,1

/axl,y,Prong Enforced Motion	! XY PLOT OF ENFORCED PRONG MOTION
*vplo,uy_prong(1,0),uy_prong(1,1)
/sho,png $*vplo,uy_prong(1,0),uy_prong(1,1) $/sho,close $/wait,1.5


C***************************************************************
C*** CREATE 2D GEOMETRY
C***************************************************************
/prep7

wpcs,-1,0			! PRONG
pcirc,ri,ri+t,thta1,thta2
pcirc,ri,ri+t,thta2,thta4
csys,1
k,,ri+t+h_barb,thta2
a,kp(ri+t,thta1,0),kp(ri+t,thta2,0),kp(ri+t+h_barb,thta2,0)
aadd,all
numc,all

adel,all	! ADD RADIUS TO BARB TIP
ksel,s,kp,,kp(ri+t+h_barb,thta2,0)
lslk
lfillt,lsnext(0),lsnext(lsnext(0)),rds
lsel,all
al,all
cm,prong_a,area
cm,prong_l,line

asel,none			! RECEPTICLE
lsel,none
pcirc,ri+t,ri+2*t,thta2,thta3
pcirc,ri+3*t,ri+4*t,thta2,thta3
wpro,thta3
wpof,ri+2.5*t
cswp,11,1	! LOCAL CYLINDRICAL COORDINATE SYSTEM FOR LATER USE
csys
pcirc,0.5*t,1.5*t,0,90
pcirc,0.5*t,1.5*t,90,180
aadd,all
alls,belo,area

adel,all	! ADD RADIUS TO CORNER THAT PRONG BARB PASSES PRIOR TO SNAP IN
csys,1
ksel,r,kp,,kp(ri+t,thta2,0)
lslk,r
lfillt,lsnext(0),lsnext(lsnext(0)),rds
lsel,all
cmse,u,prong_l,line
al,all
cm,rcptcl_a,area

alls
aplo


C***************************************************************
C*** EXTRUDE 2D GEOMETRY INTO 3D
C***************************************************************

csys

vsel,none
cmse,s,prong_a
vext,all,,,0,0,t
cm,prong_v,volu

vsel,none
cmse,s,rcptcl_a
vext,all,,,0,0,t
cm,rcptcl_v,volu

alls
vplo


C***************************************************************
C*** ATTRIBUTES, MESH
C***************************************************************
etcon,set

et,1,186		! SOLID ELEMENT TYPES
mp,ex,1,E
mp,nuxy,1,nu

et,200,200,7		! MESH SEGMENTS TO MESH 2D GEOMETRY @ z=0
asel,s,loc,z
alls,belo,area

csys,1			! REFINED MESH AT RADIUSED CORNERS
ksel,r,loc,y,0.95*thta2,1.05*thta2
ksel,r,loc,x,ri+t,ri+t+h_barb
kesi,all,esz1

esiz,esz2		! MESH SIZE ELSEWHERE

ames,all		! MESH 2D GEOMETRY @ z=0 ("SEED" MESH FOR UPCOMING SWEEP)

eplo

esiz,esz2		! SWEEP MESH VOLUMES
vswe,all

asel,s,loc,z		! DELETE 2D "SEED" MESH
acle,all
etde,200
numc,type

eplo


C***************************************************************
C*** RELOCATE PRONG TO STARTING POSITION
C***************************************************************
alls
cmse,all
csys
vgen,2,prong_v,,,0,dy,0,,,1

alls
eplo

wpcs,-1,0	! LOCAL CYLINDRICAL COORDINATE SYSTEM FOR LATER USE
wpof,,dy
cswp,12,1

fini


C***************************************************************
C*** BCs
C***************************************************************
/solu

time,1

csys,12		! DISPLACEMENTS AT BASE OF PRONG
nsel,s,loc,y,thta4
cm,prong_base_n,node
d,all,ux
d,all,uy,%uy_prong%
d,all,uz

csys,1		! DISPLACEMENTS AT BASE OF RECEPTICLE
nsel,s,loc,y,thta2
nsel,r,loc,x,ri+3*t,ri+4*t
d,all,all

*dim,t_rslts,,30
*vfil,t_rslts,ramp,1/30,1/30
outr,all,%t_rslts%

alls		! CREATE A PLOT TO ORIENT THE USER
/pbc,u,1
eplo
/sho,png $eplo $/sho,close $/wait,1.5

fini

/prep7


C***************************************************************
C*** CONTACT
C***************************************************************

*if,k_complete,eq,1,then

csys,11			! IDENTIFY/NAME TARGET NODES ON RECEPTACLE CONTACT SURFACES
ksel,s,loc,x,1.5*t
ksel,r,loc,y,0,180
csys,1
ksel,a,loc,x,ri+t
ksel,a,loc,y,thta2
ksel,u,loc,x,ri+3*t,ri+4*t
lslk,s,1
asll,s,1
nsla,s,1
cmse,s,rcptcl_v
eslv
nsel,r,ext
cm,target_n,node

csys,12			! IDENTIFY/NAME CONTACT NODES ON PRONG CONTACT SURFACES
ksel,s,loc,x,ri+t,ri+t+h_barb
lslk,s,1
asll,s,1
nsla,s,1
cm,contact_n,node

et,2,170	! ELEMENT TYPE 2: TARGET ELEMENT
et,3,174	! ELEMENT TYPE 3: CONTACT ELEMENT
keyo,3,2,1	! PURE PENALTY

r,2,,,fkn	! PENALTY STIFFNESS

alls
real,2

type,2		! CREATE TARGET ELEMENTS ON RECEPTACLE CONTACT SURFACES
cmse,s,target_n
esurf

type,3		! CREATE CONTACT ELEMENTS ON PRONG CONTACT SURFACES
cmse,s,contact_n
esurf

fini


C***************************************************************
C*** SOLVE
C***************************************************************
/solu

alls
nlge,on
solv

fini


C***************************************************************
C*** POST PROCESS
C***************************************************************
/post1

set,last
plns,s,eqv
antime,50,.1,,1,2


*endif


C***************************************************************
C*** POST PROCESS MACRO TO PLOT INSERTION FORCE
C***************************************************************
wpst,,,,,,,,0

*create,f_insert,mac

fini
/post26

csys,12		! SELECT CONSTRAINED NODES ON PRONG
nsel,s,loc,y,thta4
*get,nnds,node,,count

nd=0		! NODE NUMBER INTIALIZATION

*do,i,1,nnds	! LOOP OVER NODES, ACCUMULATE NET RACTION IN VARIABLE #2
 nd=ndnext(nd)
 rfor,3,nd,f,y
 add,2,2,3,,F_insertion
*enddo

/axl,y,Net Insertion Force
plva,2		! PLOT NET REACTION FORCE

fini
/post1

*end

*abbr,F_INSERT,f_insert	! TOOLBAR BUTTON TO CALL f_insert.mac
abbs
abbr

/eof


















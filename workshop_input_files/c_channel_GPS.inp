fini
/cle

/esha,1
/vie,1,1,1,3

/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15 

/sys,del file*.png 


C*************************************************************
C*** PARAMETERS
C*************************************************************
k_complete=0

kop3=5		! KEYOPT 3 SETTING: 0 - PLANE STRESS, 2 - PLANE STRAIN, 3 - PLANE STRESS w/THK, 5 - GPS

t=0.05		! C CHANNEL WEB AND FLANGE THICKNESS
h=0.50		! C CHANNEL HEIGHT
w=0.40		! C CHANNEL WIDTH
r_fillet=t	! FILLET RADIUS

esz=t/7		! MESH SIZE

E=2e11		! ELASTIC MODULUS
nu=0.3		! POISSON'S

P=10*101000	! PREsSURE ON TOP OF C CHANNEL


thk=0.01	! USED FOR PLANE STRESS w/THK (kop3=3)
F_axial=10e6	! USED FOR GPS (kop3=5)
l=1		! USED FOR GPS (kop3=5)


*if,kop3,eq,0,then
 /title,PLANE STRESS (keyopt(3)=0)
*elseif,kop3,eq,2,then
 /title,PLANE STRAIN (keyopt(3)=2)
*elseif,kop3,eq,3,then
 /title,PLANE STRESS w/THICKNESS = %thk% (keyopt(3)=3)
*elseif,kop3,eq,5,then
 /title,GENERALIZED PLANE STRAIN, F_axial = %F_axial% (keyopt(3)=5)
*endif


C*************************************************************
C*** GEOMETRY
C*************************************************************
/prep7

rect,,w,,t			! C-CHANNEL GEOMETRY
rect,,t,,h
rect,,w,h-t,h
asel,none
rect,,t+r_fillet,,t+r_fillet
agen,2,all,,,0,h-t-r_fillet
alls
aovl,all

cm,scrap1_a,area		! NAME THE GEOMETRY

asel,none

wpcs,-1,0			! BOTTOM FILLET
wpof,t+r_fillet,t+r_fillet
pcirc,r_fillet

wpcs,-1,0			! TOP FILLET
wpof,t+r_fillet,h-t-r_fillet
pcirc,r_fillet

cm,scrap2_a,area		! NAME THE FILLETS

alls				! BOOLEANS
asba,scrap1_a,scrap2_a
aadd,all

asum				! GET CROSS SECTION AREA
*get,area,area,,area

wpst,,,,,,,,0			! TURN OFF THE WORKPLANE SYMBOL


C*************************************************************
C*** ATTRIBUTES, MESH
C*************************************************************
et,1,182			! ELEMENT TYPE

mp,ex,1,E			! MATERIAL PROPERTIES
mp,nuxy,1,nu

esiz,esz
ames,all			! MESH


C*************************************************************
C*** LOADS, BCs
C*************************************************************

nsel,s,loc,y			! IN-PLANE BOUNDARY CONDITIONS
d,all,uy
nsel,r,loc,x
d,all,ux

nsel,s,loc,y,h			! IN-PLANE PRESSURE LOAD
sf,all,pres,P

alls
/pbc,u,,1
/psf,pres,,2
eplo


*if,k_complete,eq,1,then


keyo,1,3,kop3			! SET KEYOPTION 3

*if,kop3,eq,3,then		! IF KEYOPT(3)=3 (PLANE STRESS w/THK)
 r,1,thk			! DEFINE THICKNESS
*elseif,kop3,eq,5,then		! IF KEYOPT(3)=5 (GENERALIZED PLANE STRAIN)
 gsgd,l				! DEFINE GENERALIZED PLANE STRAIN "FIBER" DATA
 gsbd,f,F_axial,rotx,0,roty,0	! DEFINE GPS FIBER END BOUNDARY CONDITIONS
*endif


fini


C*************************************************************
C*** SOLVE
C*************************************************************
/solu
alls
save
alls
solv


C*************************************************************
C*** POST PROCESS
C*************************************************************
/post1

/pbc,u,,1
/psf,pres,,2
eplo
/sho,png $eplo $/sho,close $/wait,2

plns,s,eqv
/sho,png $plns,s,eqv $/sho,close $/wait,2

plns,s,x
/sho,png $plns,s,x $/sho,close $/wait,2

plns,s,y
/sho,png $plns,s,y $/sho,close $/wait,2

plns,s,z
/sho,png $plns,s,z $/sho,close $/wait,2

plns,epel,z
/sho,png $plns,epel,z $/sho,close $/wait,2

*endif

/eof

sz=f_axial/area

kz=E*area/l

l_fiber=f_axial/kz

epelz=(sz/E)/(1-nu)


fini
/post26
gssol,2,length
prva,2
fini
/cle

/vup,1,z
/vie,1,1,-1,2

/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  

/pnu,mat,1
/num,1

/esha,1

/sys,del file*.png


C**************************************************
C*** PARAMETERS (DIMENSIONS, MESH SIZE)
C**************************************************
k_complete=1	! 1: RUN TO COMPLETION, 0: USER COMPLETES THE MODEL

pi=acos(-1)

l_plate=0.250	! PLATE LENGTH
w_plate=0.350	! PLATE WIDTH
t_plate=0.050	! PLATE THICKNESS

s_tube=0.075	! TUBE CENTER-CENTER SPACING
bends=3		! NUMBER OF TUBE BENDS AT ENDS (ODD NUMBERS ONLY)

OD_tube=0.025	! TUBE OD
ID_tube=0.022	! TUBE ID
l_tube_end=0.20	! LENGTH TUBE INLET AND OUTLET EXTENDS BEYOND PLATE EDGE

esz1=pi*OD_tube/24	! TUBE MESH SIZE
esz2=t_plate/3		! PLATE MESH SIZE



C**************************************************
C*** PARAMETERS (PROPERTIES)
C**************************************************
k_plate=200		! PLATE THERMAL CONDUCTIVITY (W/m-C)
k_tube=450		! TUBE THERMAL CONDUCTIVITY (W/m-C)

k_fluid=0.63		! FLUID THERMAL CONDUCTIVITY (W/m-C)
C_fluid=4200		! FLUID SPECIFIC HEAT (J/kg-C)
dnsty_fluid=985		! FLUID DENSITY (kg/m^3)


C**************************************************
C*** PARAMETERS (LOADS, BOUNDARY CONDITIONS)
C**************************************************
Q_plate=25000		! HEAT APPLIED TO TOP SURFACE OF PLATE (W)

P_inlet=1624		! INLET PRESSURE (N/m^2)
mdot_inlet=0.5		! INLET MASS FLOWRATE (kg/s)
T_inlet=22		! INLET TEMPERATURE (C)

Hf=100			! CONVECTION COEFFICIENT (W/m^2-C)


C**************************************************
C*** SOME EXPECTED RESULTS...
C**************************************************

a_flow=pi*(ID_tube/2)**2	! FLOW CROSS SECTION AREA (DO NOT EDIT)

V_fluid_expected=(mdot_inlet/dnsty_fluid)/a_flow	! EXPECTED FLUID VELOCITY

T_outlet_expected = T_inlet+Q_plate/(mdot_inlet*C_fluid)	! EXPECTED FLUID OUTLET TEMPERATURE



C**************************************************
C*** CONVECTION COEFFICIENT TABLE; Hf{V_fluid,TEMP}
C**************************************************
C************************************************
C***
C*** SOURCE: J.P. Holman, Heat Transfer, 4th Edition, pg 204, eq 6-4
C***
C*** Nu = 0.023 * Re^0.8 * Pr^0.4
C***
C*** Re = (dens*V*d)/VISC
C***
C*** dens = density (kg/m^3)
C*** V = fluid mean velocity (m/s)
C*** d = tube diameter (m)
C*** VISC = dynamic viscosity (e.g., kg/m-s)
C***
C*** Hf = (k/d)*Nu
C***
C************************************************

*dim,temps,,8		! LIST OF TEMPERATURES FROM TABLE A-9, pg 507
temps(1)=21.11,32.22,43.33,54.44,65.55,76.67,87.78,104.4

*dim,Pr,table,8,,,temp		! Pr{TEMP} FROM TABLE A-9, pg 507
Pr(1,1)=6.78,5.12,4.04,3.30,2.73,2.33,2.03,1.66
Pr(1,0)=21.11,32.22,43.33,54.44,65.55,76.67,87.78,104.4

/axl,x,Temperature (C)		! PLOT Pr{TEMP}
/axl,y,Prandtl Number
*vplo,Pr(1,0),Pr(1,1)
/sho,png $*vplo,Pr(1,0),Pr(1,1) $/sho,close $/wait,1.5


*dim,vscsty,table,8,,,temp 	! Dynamic Viscosity{TEMP} FROM TABLE A-9, pg 507
vscsty(1,1)=9.8e-4,7.65e-4,6.16e-4,5.13e-4,4.3e-4,3.72e-4,3.27e-4,2.67e-4
vscsty(1,0)=21.11,32.22,43.33,54.44,65.55,76.67,87.78,104.4

/axl,x,Temperature (C)		! PLOT vscsty{TEMP}
/axl,y,Dynamic Viscosity (kg/m-s)
*vplo,vscsty(1,0),vscsty(1,1)
/sho,png $*vplo,vscsty(1,0),vscsty(1,1) $/sho,close $/wait,1.5


*dim,Hftable,table,11,8,,velocity,temp	! FILM COEFFICIENT Hf{V,TEMP}

v_water1=0.2	! LOWEST FLUID VELOCITY
v_water2=2.0	! HIGHEST FLUID VELOCITY


*do,j,1,8	! LOOP OVER 8 TEMPERATURES
	i=0
	*do,v_water,v_water1,v_water2,(v_water2-v_water1)/10	! LOOP OVER RANGE OF FLUID VELOCITIES
		i=i+1
		Re = (dnsty_fluid*v_water*ID_tube)/vscsty(temps(j))
		Nu = 0.023*(Re**0.8)*(Pr(temps(j))**0.4)
		HFtable(i,j) = (k_fluid/ID_tube)*Nu
	*enddo						! END FLUID VELOCITY LOOP
*enddo							! END TEMP LOOP


i=0
*do,v_water,v_water1,v_water2,(v_water2-v_water1)/10	! FLUID VELOCITIES IN COLUMN 0
	i=i+1
	HFtable(i,0) = v_water
*enddo

*do,j,1,8						! TEMPERATURES IN ROW 0
	HFtable(0,j)=temps(j)
*enddo


/axl,x,Fluid Velocity (m/s)		! AXES LABELS FOR PLOT OF Hf{V,TEMP}
/axl,y,Hf (W/m^2-C)

*do,j,1,8
	/gcol,j,%temps(j)%
*enddo

*vplot,Hftable(1,0),Hftable(1,1),2,3,4,5,6,7,8
/sho,png $*vplot,Hftable(1,0),Hftable(1,1),2,3,4,5,6,7,8 $/sho,close $/wait,1.5


C**************************************************
C*** GEOMETRY (DRAG/FLUID116 LINES)
C**************************************************
/prep7

wpcs,-1,0
wpof,-(bends/2)*s_tube
csys,4
k,1
k,2,,l_tube_end
k,3,,l_tube_end+l_plate/2
k,4,,l_tube_end+l_plate
kgen,2,4,,,s_tube/2,s_tube/2,,1
kgen,2,4,,,s_tube,,,2
kgen,2,3,,,s_tube,,,4

l,1,2
l,2,3
l,3,4

kwpa,4
wpof,s_tube/2
cswp,11,1
l,4,5
l,5,6
csys
l,6,7


/num
/pnu,kp,1
/pnu,line,1
lplo


*if,bends,gt,1,then
 csys,4
 wpof,,-l_plate/2
 lsym,y,3,6
 lgen,2,7,10,,s_tube,,,,,1
 lgen,nint(bends/2),3,6,,2*s_tube
 lgen,nint(bends/2)-1,7,10,,2*s_tube
*endif 


*get,kmax,kp,,num,max

wpcs,-1,0
wpof,(bends/2)*s_tube
csys,4
k,kmax+1,,l_tube_end
k,kmax+2
l,kp(0,l_tube_end+l_plate/2,0),kmax+1
l,kmax+1,kmax+2


numm,kp
numc,line

cm,fluid116_l,line
latt,3,3,3

*get,nlines,line,,count

/num
/pnum,line,1
/psy,ldir,1
lplo
/sho,png $lplo $/sho,close $/wait,1.5
/num,1
/pnum,line
/psy,ldir


C**************************************************
C*** GEOMETRY (TUBE AND FLUID VOLUMES)
C**************************************************
wpcs,-1,0
wpof,-(bends/2)*s_tube
wpro,,-90

pcirc,ID_tube/2,OD_tube/2,0,90		! TUBE CROSS SECTION AREAS
pcirc,ID_tube/2,OD_tube/2,90,180
pcirc,ID_tube/2,OD_tube/2,180,270
pcirc,ID_tube/2,OD_tube/2,270,360

pcirc,ID_tube/2,,0,90		! FLUID CROSS SECTION AREAS
pcirc,ID_tube/2,,90,180
pcirc,ID_tube/2,,180,270
pcirc,ID_tube/2,,270,360

gplo
/sho,png $gplo $/sho,close $/wait,1.5



FLST,2,4,5,ORDE,2	! DECLARE TUBE CROSS SECTION AREAS FOR USE IN DRAG OPERATION
FITEM,2,1   
FITEM,2,-4  

FLST,8,nlines,4		! SPECIFY DRAG LINES (IN ORDER!)

ln1=1
k1=1
k2=0

*do,i,1,nlines
 lsel,s,line,,ln1
 *get,ln1,line,,num,max

 fitem,8,ln1

 *get,k2,line,ln1,kp,2
 ksel,s,kp,,k2
 lslk
 lsel,u,line,,ln1
 *get,ln1,line,,num,max
*enddo

alls			! DRAG AREAS ALONG DRAG LINES TO CREATE TUBE VOLUMES
VDRAG,P51X, , , , , ,P51X   

numm,kp
cm,tube_v,volu
vatt,2,2,2



FLST,2,4,5,ORDE,2	! DECLARE FLUID CROSS SECTION AREAS FOR USE IN DRAG OPERATION
FITEM,2,5
FITEM,2,-8   

FLST,8,nlines,4		! SPECIFY DRAG LINES (IN ORDER!)

ln1=1
k1=1
k2=0

*do,i,1,nlines
 lsel,s,line,,ln1
 *get,ln1,line,,num,max

 fitem,8,ln1

 *get,k2,line,ln1,kp,2
 ksel,s,kp,,k2
 lslk
 lsel,u,line,,ln1
 *get,ln1,line,,num,max
*enddo

alls			! DRAG AREAS ALONG DRAG LINES TO CREATE TUBE VOLUMES
vsel,none
VDRAG,P51X, , , , , ,P51X   

cm,fluid_v,volu
vatt,200,200,200

alls
numm,kp

gplo
/sho,png $gplo $/sho,close $/wait,1.5


C**************************************************
C*** BLOCK GEOMETRY, BOOLEAN SUBTRACTION
C**************************************************
wpcs,-1,0
wpof,,l_tube_end+l_plate/2

vsel,none
bloc,-w_plate/2,w_plate/2,-l_plate/2,l_plate/2,-t_plate/2,t_plate/2
cm,scrap1_v,volu

cmse,s,tube_v			! SUBTRACT TUBE FROM BLOCK
cmse,a,fluid_v
cm,scrap2_v,volu

cmse,a,scrap1_v
alls,belo,volu
vsbv,scrap1_v,scrap2_v,,dele,keep
cmse,u,scrap2_v
cm,plate_v,volu
vatt,1,1,1

alls
cmse,all
cmde,scrap2_v
cmplo



C**************************************************
C*** NAMED TUBE WETTED SURFACES FOR AFSURF
C**************************************************
cmse,s,tube_v
aslv
cmse,s,fluid_v
aslv,r

aplo
cm,wetted_a,area


C**************************************************
C*** ATTRIBUTES,  MESH (SOLID CONDUCTION DOMAINS)
C**************************************************
et,1,70
mp,kxx,1,k_plate

et,2,70
mp,kxx,2,k_tube

esiz,esz1
vsel,s,mat,,2
vmes,all

esiz,esz2
msha,1
vsel,s,mat,,1
vmes,all

alls
/pnu,mat,1
/num,1
eplo


C**************************************************
C*** HEAT LOAD ON PLATE
C**************************************************
vsel,s,mat,,1
alls,belo,volu
asel,r,loc,z,t_plate/2
sfa,all,,hflux,Q_plate/(w_plate*l_plate)


C**************************************************
C*** FLUID116 AND SURF152 ELEMENT ATTRIBUTES
C**************************************************
et,3,116,0,1

mp,kxx,3,k_fluid
mp,c,3,c_fluid
mp,dens,3,dnsty_fluid

mptemp,1,temps(1),temps(2),temps(3),temps(4),temps(5),temps(6)	! TEMPERATURE DEPENDENT VISCOSITY
mptemp,7,temps(7),temps(8)
mpdata,visc,3,1,vscsty(temps(1)),vscsty(temps(2)),vscsty(temps(3)),vscsty(temps(4)),vscsty(temps(5)),vscsty(temps(6))
mpdata,visc,3,7,vscsty(temps(7)),vscsty(temps(8))

r,3,ID_tube,(pi*ID_tube**2)/4

et,4,152
keyo,4,4,1	! NO MIDSIDE NODES
keyo,4,5,1	! 1 EXTRA NODE CONNECTS TO FLUID116
keyo,4,8,4	! Hf EVALUTED AT Tbulk
!r,4



*if,k_complete,eq,1,then

C**************************************************
C*** FLUID116 MESH
C**************************************************
cmse,s,fluid116_l

lmes,all


C**************************************************
C*** SURF152 MESH (JOINED TO FLUID116 THRU EXTRA NODES)
C**************************************************
cmse,s,wetted_a
type,4

afsurf,'wetted_a','fluid116_l'


C**************************************************
C*** FLUID116 BCs
C**************************************************
cmse,s,fluid116_l
alls,belo,line

csys
dk,kp((bends/2)*s_tube,0,0),pres,0		! OUTLET PRESSURE = 0
dk,kp(-(bends/2)*s_tube,0,0),temp,T_inlet	! INLET TEMPERATURE = T_inlet

!dk,kp(-(bends/2)*s_tube,0,0),pres,P_inlet	! OPTIONAL: SPECIFY INLET PRESSURE
fk,kp(-(bends/2)*s_tube,0,0),flow,mdot_inlet	! NOTE: FLOW IS MASS FLOWRATE (kg/s)


C**************************************************
C*** SURF152 FILM COEFFICIENT
C**************************************************
esel,s,ename,,152
sfe,all,,conv,1,%Hftable%

fini

cmde,fluid_v


C**************************************************
C*** SOLVE
C**************************************************
/solu
alls
cmse,all
save
solv
fini


C**************************************************
C*** POST
C**************************************************
/post1

/pnu,mat,1
/num,1

cmplot				! PLOT ALL COMPONENTS
/sho,png $cmplot $/sho,close $/wait,1.5

/psf,hflu,,2			! ELEMENT PLOT w/HEAT FLUX SHOWN
eplot
/sho,png $eplot $/sho,close $/wait,1.5
/psf,hflu

cmse,s,fluid116_l		! PLOT FLUID116 LINES AND SURF152 AREAS
cmse,a,wetted_a
cmplot
/sho,png $cmplot $/sho,close $/wait,1.5

alls
cmse,all

plns,temp			! TEMPERATURE CONTOUR PLOT
/sho,png $plns,temp $/sho,close $/wait,1.5

esel,s,ename,,116		! FLUID116 TEMPERATURE
/ann,dele
/tla,-0.25,0.90,Expected Outlet Temperature = %T_outlet_expected% C
plns,temp
*get,Tmin,plnsol,,min
*get,Tmax,plnsol,,max
/sho,png $plns,temp $/sho,close $/wait,1.5

plns,pres			! FLUID116 PRESSURE
/sho,png $plns,pres $/sho,close $/wait,1.5

etab,v_fluid,nmisc,1		! READ FLUID VELOCITY INTO ELEMENT TABLE
etab,Re,nmisc,2			! READ FLUID REYNOLDS NUMBER INTO ELEMENT TABLE

*get,v_fluid,elem,elnext(0),etab,v_fluid	! CHECK Hftable FOR EXPECTED RANGE OF Hf ON WETTED SURFACE
Hf1=Hftable(v_fluid,Tmin)
Hf2=Hftable(v_fluid,Tmax)

/ann,dele
/tla,-0.25,0.90,Expected Fluid Velocity = %V_fluid_expected% m/s
/tla,-0.45,0.85,Expected Range of Hf from Lookup Table:
/tla,-0.25,0.80,%Hf1% to %Hf2% W/m^2-C

plet,v_fluid			! PLOT FLUID116 FLOW VELOCITY
/sho,png $plet,v_fluid $/sho,close $/wait,1.5

plet,Re				! PLOT FLUID116 REYNOLD'S NUMBER
/sho,png $plet,Re $/sho,close $/wait,1.5

esel,s,ename,,152		! PLOT SURF152 Hf
etab,hf,nmisc,5
plet,hf
/sho,png $plet,hf $/sho,close $/wait,1.5

*endif


/eof

















k_fluid=0.58		! FLUID THERMAL CONDUCTIVITY (W/m-C)
C_fluid=4200		! FLUID SPECIFIC HEAT (J/kg-C)
dnsty_fluid=1000	! FLUID DENSITY (kg/m^3)
vscsty_fluid=0.001	! FLUID VISCOSITY 

Q_plate=1000		! HEAT APPLIED TO TOP SURFACE OF PLATE (W)














/eof

vsum


C**************************************************
C*** IDENTIFY (UNUSED) VOLUMES INSIDE TUBES
C**************************************************
*get,nvolus,volu,,count

vlm=0
v_vlm_max=0

*do,i,1,nvolus
! cmse,s,scrap_v
 vlm=vlnext(vlm)
! vsel,r,volu,,vlm
 *get,v_vlm,volu,vlm,volu
 *if,v_vlm,gt,v_vlm_max,then
  v_vlm_max=v_vlm
  vnum=vlm
 *endif
*enddo


vsel,s,volu,,vnum
vsel,inve
cmse,r,scrap_v
alls,belo,volu
vdel,all,,,1

cmse,s,scrap_v
cm,plate_v,volu
vatt,1,1,1
cmde,scrap_v

 
alls
cmse,all
cmplo


/eof
























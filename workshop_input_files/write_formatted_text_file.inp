fini
/cle


/vup,1,z
/vie,1,3,-2,1

/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  


C*******************************************
C*** DIMENSIONS
C*******************************************
k_complete=0	! 1: RUN WORKSHOP TO COMPLETION

l=0.250		! BEAM LENGTH
w=0.050		! BEAM WIDTH
t=0.010		! BEAM THICKNESS

esz=t/2		! MESH SIZE

E=2e11		! ELASTIC MODULUS
nu=0.3		! POISSON'S

F_tip=-10	! FORCE ACTING AT TIP


C*******************************************
C*** MODEL
C*******************************************
/prep7

bloc,,l,,w,,t	! GEOMETRY

etcon,set

et,1,185	! ELEMENT ATTRIBUTES
mp,ex,1,E
mp,nuxy,1,nu

esiz,esz	! MESH VOLUME
vmes,all

fini


C*******************************************
C*** SOLVE
C*******************************************
/solu

nsel,s,loc,x		! CONSTRAINT AT FIXED END
d,all,all

nsel,s,loc,x,l		! TIP LOAD
nsel,r,loc,z,t
cp,1,uz,all
f,ndnext(0),fz,F_tip

alls			! SOLVE
solv
fini


C*************************************************************************
C*** POST PROCESS: WORK DONE ON SYSTEM BY APPLIED LOAD
C*************************************************************************
/post1

/pbc,u,,1			! SHOW IMPOSED BCs/LOADS
/pbc,cp,,1
/pbc,f,,1
/vsc,1,2.5
/hbc,1,1

plns,u,z,2			! CONTOUR PLOT OF UZ

*get,uzmin,plnsol,,min		! GET MINIMUM UZ VALUE FROM LAST CONTOUR PLOT
Uelas_tot1=0.5*uzmin*F_tip	! WORK DONE ON SYSTEM BY APPLIED FORCE

/tla,-0.60,0.80,  Work Done by Applied Load = 0.5*F_tip*U_tip = %Uelas_tot1%

etab,Uelas,sene			! READ ELEMENTAL STRAIN ENERGY INTO ELEMENT TABLE
pletab,Uelas,1			! CONTOUR PLOT OF STRAIN ENERGY
/wait,0.5




*create,sene_out,mac		! ADD THE FOLLOWING LINES OF APDL CODE TO MACRO sene_out.mac

C*************************************************************************
C*** POST PROCESS: WRITE ELEMENT NUMBERS AND CORRESPONDING STRAIN 
C*** ENERGIES OF SELECTED SUBSET OF ELEMENTS TO A FORMATTED TEXT FILE
C*************************************************************************

/pmacro

*del,Uelas_array	! DELETE ARRAYS CREATED BY PREVIOUS MACRO INVOCATION
*del,mask
*del,elnums

alls
/ann,dele			! ANNOTATION FOR PLOT
/tla,-0.60,0.80,  Work Done by Applied Load = 0.5*F_tip*U_tip = %Uelas_tot1%
pletab,Uelas,1			! CONTOUR PLOT OF STRAIN ENERGY


C*************************************************************************
C*** PROVIDE INSTRUCTIONS TO USER IN MESSAGE DIALOGUE BOX
C*************************************************************************
*msg,ui
Pick the elements whose strain energies you want saved to text file %/&
"Uelas.txt". A plot of the strain energy of the selected elements%/&
will be produced, annotated with their total value.

esel,s,p			! USER PICKS ELEMENTS FOR STRAIN ENERGY TOTAL AND OUTPUT TO TEXT FILE
cm,temp_e,elem			! TEMPORARY COMPONENT NAME ASSIGNED TO USER-SELECTED ELEMENTS

*vget,mask,elem,1,esel			! READ ELEMENT SELECT STATUS INTO MASK VECTOR NAMED "mask"

alls

*vmask,mask(1)				! USE MASK ARRAY (WILL BECOME INACTIVE AFTER NEXT CMD)
*vget,elnums,elem,1,elist		! READ ELEMENT NUMBERS OF SELECTED (UNMASKED) ELEMENTS INTO ARRAY elnums

*vmask,mask(1)					! USE MASK ARRAY AGAIN
*vget,Uelas_array,elem,1,etab,Uelas		! READ STRAIN ENERGIES OF SELECTED (UNMASKED) ELEMENTS INTO ARRAY Uelas

*cfopen,Uelas,txt				! OPEN TEXT FILE “Uelas.txt”
*vwrite						! WRITE A HEADER TO THE TEXT FILE
('Element Number   Element Strain Energies')
*vmask,mask(1)					! USE MASK ARRAY TO ELIMINATE GAPS IN ARRAYS BEING WRITTEN TO TEXT FILE
*vwrite,elnums(1),Uelas_array(1)		! WRITE ELEMENT NUMBERS & STRAIN ENERGIES TO THE TEXT FILE
(3X,F6.0,14X,E10.4)
*cfclose					! CLOSE THE TEXT FILE

*vscfun,Uelas_tot2,sum,Uelas_array(1)		! Uelas_tot2 = SUM OF ALL ENTRIES IN Uelas

/tla,-0.50,0.75,Net Strain Energy in the Selected Elements = %Uelas_tot2%
/tla,-0.50,0.70,The Selected Element Numbers and their Corresponding
/tla,-0.50,0.65,Strain Energies Have Been Written to Text File Uelas.txt

cmse,s,temp_e			! RESELECT ELEMENTS ORIGINALLY SELECTED BY USER

pletab,Uelas,1			! CONTOUR PLOT OF STRAIN ENERGY

*end				! STOP SENDING CODE TO sene_out.mac


C*************************************************************************
C*** CREATE TOOLBAR BUTTON TO CALL MACRO
C*************************************************************************

*abbr,sene_out,sene_out		! DEFINE AN ABBREVIATION NAMED sene_out TO INVOKE sene_out.mac
abbs				! SAVE DEFINED ABBREVIATIONS TO jobname.abbr
abbr				! "RESTORE" ABBREVIATIONS (CREATES TOOLBAR BUTTON TO CALL MACRO sene_out.mac)

*if,k_complete,eq,1,then

sene_out			! INVOKE sene_out.mac

*endif

/eof



















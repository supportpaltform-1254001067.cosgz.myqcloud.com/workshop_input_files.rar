fini
/cle

/vie,1,1,-3,1
/vup,1,z
/dsc,1,1

/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15 

/file,bonded_plates


C*********************************************************
C*** PARAMETERS
C*********************************************************
k_complete=1	! 1: COMPLETE MODEL, OTHERWISE USER DEFINES CONTACT

l=1.00		! PLATE LENGTH (m)
w=0.200		! PLATE WIDTH
t=0.025		! PLATE THICKNESS

overlap=0.15	! PLATE OVERLAP (LENGTH OF BONDED CONTACT)

esz=0.75*t	! ELEMENT SIZE

E=2e11		! ELASTIC MODULUS (N/m^2)
nu=0.3		! POISSON'S

F_tip=-500	! TIP LOAD (N)


C*********************************************************
C*** GEOMETRY
C*********************************************************
/prep7
bloc,,l,,w,,t
wpof,l-overlap,,t
bloc,,l,,w,,t


C*********************************************************
C*** ATTRIBUTES, MESH
C*********************************************************
etcon,set

et,1,186
mp,ex,1,E
mp,nuxy,1,nu

esiz,esz
vmes,all


C*********************************************************
C*** BCs, LOADS
C*********************************************************
nsel,s,loc,x
d,all,all

nsel,s,loc,x,2*l-overlap
nsel,r,loc,z,2*t
cp,1,uz,all
f,ndnext(0),fz,F_tip

/pbc,all,,1
alls
eplo


C*********************************************************
C*** MANUALLY CREATE BONDED CONTACT
C*********************************************************

*if,k_complete,eq,1,then

 et,2,170		! TYPE 2: TARGET ELEMENTS

 et,3,174		! TYPE 3: CONTACT ELEMENTS
 keyo,3,12,5		! BONDED CONTACT
 keyo,3,4,1		! FORCE-BASE CONSTRAINT
 keyo,3,2,2		! MPC ALGORITHM

 r,2			! DEFINE REAL CONSTANT SET #2 - ALLOW DEFAULTS

 real,2			! ACTIVATE REAL CONSTANT ATTRIBUTE ID #2 - MUST BE SHARED BY CONTACT & TARGET ELEMS

 type,2			! ACTIVATE ELEMENT TYPE ATTRIBUTE ID #2 (CONTACT ELEMENTS)

 ksel,s,loc,x,0,l	! SELECT NODES ON TOP SURFACE OF LOWER PLATE
 ksel,r,loc,z,t
 lslk,s,1
 asll,s,1
 nsla,s,1
 esurf			! CREATE TARGET ELEMENTS (TYPE,2/REAL,2)

 type,3			! ACTIVATE ELEMENT TYPE ATTRIBUTE ID #3 (TARGET ELEMENTS)

 ksel,s,loc,x,l-overlap,2*l-overlap	! SELECT NODES ON BOTTOM SURFACE OF UPPER PLATE
 ksel,r,loc,z,t
 lslk,s,1
 asll,s,1
 nsla,s,1
 esurf			! CREATE CONTACT ELEMENTS (TYPE,3/REAL,2)

 fini

 /solu			! SOLVE
 alls
 solv
 fini

 /post1			! POST PROCESS
 plns,u,z,2

*endif




























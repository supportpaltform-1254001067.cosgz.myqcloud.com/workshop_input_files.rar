

finish
/clear

/vie,1,1,2,3
/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  

/sys,del file*.png


C*****************************************************
C*** PARAMETERS (MKS)
C*****************************************************
k_complete=0		! 0: USER COMPLETES EXERCISE, 1: RUN TO COMPLETION

ri_tube=0.125		! TUBE INNER RADIUS (m)
ro_tube=0.150		! TUBE OUTER RADIUS

r_fin=0.250		! FIN OUTER RADIUS
t_fin=0.010		! FIN THICKNESS

r_fillet=0.005		! FILLET RADIUS

s_fin=0.050		! FIN SPACING

esz=t_fin/5		! MESH SIZE

k=60			! THERMAL CONDUCTIVITY (W/m-C)
E=2e11			! ELASTIC MODULUS (N/m^2)
nu=0.3			! POISSON'S
cte=5e-6		! THERMAL COEFFICIENT OF EXPANSION (C^-1)

hf_air=15		! CONVECTION COEFFICIENT ON EXTERIOR (W/m^2-C)
tbulk_air=22		! BULK TEMPERATURE ON EXTERIOR (deg C)

hf_steam=45		! CONVECTION COEFFICIENT INSIDE TUBE (W/m^2-C)
tbulk_steam=225		! BULK TEMPERATURE INSIDE TUBE (deg C)

pres_i=7e6		! INTERNAL PRESSURE (N/m^2)


C*****************************************************
C*** GEOMETRY
C*****************************************************
/prep7

rect,ri_tube,ro_tube,0,s_fin/2		! TUBE
rect,ro_tube,r_fin,0,t_fin/2		! FIN

wpof,ro_tube+r_fillet,t_fin/2+r_fillet	! BLOCK TO CREATE FILLET
rect,-r_fillet,0,-r_fillet,0

aadd,all				! ADD AREAS
cm,scrap1_a,area			! NAME AREAS FOR UPCOMING BOOLEAN

vsel,none				! FILLET
pcirc,r_fillet
cm,scrap2_a,area			! NAME THE FILLET AREA FOR UPCOMING BOOLEAN

alls					! BOOLEAN: SUBTRACT THE FILLET
asba,scrap1_a,scrap2_a

wpst,,,,,,,,0

aplo					! PLOT THE RESULTING GEOMETRY
/sho,png $aplo $/sho,close $/wait,1.5


*if,k_complete,eq,1,then


C*****************************************************
C*** THERMAL ATTRIBUTES AND MESH
C*****************************************************
et,1,223,11,1,1		! 2D AXISYMMETRIC THERMAL CONDUCTION

mp,kxx,1,k	! DEFINE THERMAL CONDUCTIVITY
mp,ex,1,E	! DEFINE ELASTIC MODULUS
mp,nuxy,1,nu	! DEFINE POISSON'S
mp,alpx,1,cte	! DEFINE TCE


esiz,esz
ames,all

eplo
/sho,png $eplo $/sho,close $/wait,1.5


C*****************************************************
C*** THERMAL BCs
C*****************************************************
lsel,s,loc,x,ro_tube,r_fin
lsel,u,loc,y
sfl,all,conv,hf_air,,tbulk_air

lsel,s,loc,x,ri_tube
sfl,all,conv,hf_steam,,tbulk_steam


C*****************************************************
C*** STRUCTURAL BCs
C*****************************************************
lsel,s,loc,y	! SYMMETRY @ y=0
dl,all,,uy

nsel,s,loc,y,s_fin/2	! SYMMETRY @ y=s_fin/2
cp,1,uy,all

lsel,s,loc,x,ri_tube	! DEFINE TUBE PRESSURE
sfl,all,pres,pres_i,pres_i


C*****************************************************
C*** SOLVE
C*****************************************************
/solu
alls
solv
fini


C*****************************************************
C*** THERMAL POST PROCESSING
C*****************************************************
/post1


/psf,conv,hcoe,2
eplo
/sho,png $eplo $/sho,close $/wait,1.5

plns,temp
/sho,png $plns,temp $/sho,close $/wait,1.5

/expa,27,axis,full,0,10,0, 2,rect,half,0,1e-8,0, 10,rect,full,0,s_fin,0
plns,temp
/sho,png $plns,temp $/sho,close $/wait,1.5

/exp

plve,tf,,,,vect,,on
/sho,png $plve,tf,,,,vect,,on $/sho,close $/wait,1.5


C*****************************************************
C*** STRUCTURAL POST PROCESSING
C*****************************************************
/post1

/pbc,cp,,1	! IMAGE OF ALL APPLIED LOADS & BCs
/pbc,u,,1
/psf,pres,,2
eplo
/sho,png $eplo $/sho,close $/wait,1.5
/pbc,cp
/pbc,u
/psf,pres

plns,s,x
/sho,png $plns,s,x $/sho,close $/wait,1.5

/expa,27,axis,full,0,10,0, 2,rect,half,0,1e-8,0, 10,rect,full,0,s_fin,0
plns,s,x
/sho,png $plns,s,x $/sho,close $/wait,1.5

/exp

plns,epel,x
/sho,png $plns,epel,x $/sho,close $/wait,1.5

plns,epth,x
/sho,png $plns,epth,x $/sho,close $/wait,1.5

plns,s,eqv
/sho,png $plns,s,eqv $/sho,close $/wait,1.5

*endif


/eof

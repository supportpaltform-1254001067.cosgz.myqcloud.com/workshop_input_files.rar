fini
/cle

/sys,del file*.png

/hbc,1		! HIDE BC'S OBSCURED BY GEOMETRY


C************************************************
C*** PARAMETERS
C************************************************
E=30e6		! ELASTIC MODULUS (lbf/in^2)
nu=0.3		! POISSON'S
p_max=500	! PEAK PRESSURE OF SAWTOOTH


C************************************************
C*** IMPORT GEOMETRY
C************************************************
~SATIN,'crank-assy','sat',,SOLIDS,0
/face
vplo


C************************************************
C*** BOOLEAN: GLUE VOLUMES
C************************************************
/prep7
vglu,all	! GLUE ALL VOLUMES

/vie,1,1,-1,-3	! CHANGE VIEWING DIRECTION AND PLOT VOLUMES

vplo
/sho,png $vplo $/sho,close $/wait,2


C************************************************
C*** ATTRIBUTES, MESH
C************************************************
etco,set	! ELEMENT TYPE CONTROL HANDLED BY MAPDL

et,1,187	! ELEMENT TYPE: SOLID187 10 NODE TET
mp,ex,1,E	! ELASTIC MODULUS
mp,nuxy,1,nu	! POISSON'S

smrt,2		! SMART SIZE LEVEL 2
vmes,all	! MESH ALL VOLUMES


C************************************************
C*** CYLINDRICAL COORDINATE SYSTEM FOR PRESSURE LOAD
C************************************************
wpcs,-1,0	! POSITION WORKPLANE AT GLOBAL CARTESIAN ORIGIN
kwpa,21,22	! POSITION WORKPLANE BETWEEN KEYPOINTS 21 & 22
wpro,,-90	! ROTATE WORKPLANE 90 DEG ABOUT ITS X AXIS
cswp,11,1	! CREATE LOCAL CSYS 11 (CYLINDRICAL) AT WORKPLANE


C************************************************
C*** PRESSURE LOAD VARIES w/CSYS,11 THETA COORDINATE
C************************************************
*dim,p_knob,table,3,,,y,,,11	! DIMENSION TABLE ARRAY

p_knob(1,1)=0,p_max,0		! PRESSURE VALUES (SAWTOOTH - 0 - p_max - 0)
p_knob(1,0)=0,90,180		! CORRESPONDING THETA COORDINATE VALUES

/axl,x,Theta Coordinate (deg)	! LABEL AXES AND PLOT p_knob TABLE
/axl,y,Applied Pressure (psi)
*vplo,p_knob(1,0),p_knob(1,1)
/sho,png $*vplo,p_knob(1,0),p_knob(1,1) $/sho,close $/wait,2


C************************************************
C*** APPLY PRESSURE TO HANDLE
C************************************************
seltol,0.001		! LOOSEN THE SELECTION TOLERANCE A BIT

csys,11				! IN KNOB CYLINDRICAL COORDINATES
asel,s,loc,z,kz(21),kz(29)	! SELECT AREAS BY KEYPOINT Z COORDINATES
asel,u,loc,z,kz(21)		! UNSELECT THE AREA ON THE TOP OF THE KNOB

sfa,all,,pres,%P_knob%		! APPLY TABULAR LOAD TO SELECTED AREAS


C************************************************
C*** FIX INTERNAL SURFACES OF SHAFT
C************************************************
csys,5			! GLOBAL CYLINDRICAL ALIGNED WITH Y AXIS
ksel,s,loc,x,0,0.5/2	! SELECT KEYPOINTS UP TO HOLE RADIUS
ksel,r,loc,z,0,0.5	! RESELECT KEYPOINTS HOLE DEPTH
lslk,s,1		! SELECT LINES USING THESE KEYPOINTS
asll,s,1		! SELECT AREAS USING THESE LINES
asel,u,loc,z,0.5	! UNSELECT THE AREA AT THE ENDS OF THE HOLE
asel,u,loc,z,0
da,all,all		! CONSTRAIN UX,UY,UZ ON THESE AREAS

fini


C************************************************
C*** SOLVE
C************************************************
/solu
alls
save
solv
fini

/pbc,u,1	! ELEMENT PLOT SHOWING BCs (U & PRES)
/psf,pres,,2
eplo
/sho,png $eplo $/sho,close $/wait,2


C************************************************
C*** POST PROCESS
C************************************************
/post1

plns,s,eqv		! CONTOUR VON MISES STRESS
/sho,png $plns,s,eqv $/sho,close $/wait,2



/eof



/prep7
vglu,all	! GLUE ALL VOLUMES
etco,set	! ELEMENT TYPE CONTROL HANDLED BY MAPDL



/psy,csys,1	! TURN ON CSYS SYMBOLS
lplo		! PLOT LINES



*dim,pressure,table,6,,,x		! TABLE "pressure", DIMENSION=6, VARIABLE='X'
pressure(1,1)=0,50,100,150,125,0	! PRESSURE VALUES IN COLUMN 1
pressure(1,0)=0,0.5,1,2.5,2.75,5	! X COORDINATE VALUES IN COLUMN 0

/axl,x,X Coordinate			! LABEL X AXIS
/axl,y,Pressure				! LABEL Y AXIS
*vplot,pressure(1,0),pressure(1,1)	! CREATE A PLOT OF pressure TABLE ARRAY




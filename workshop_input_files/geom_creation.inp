fini
/cle

/vie,1,3,2,-1
/vup,1,z


C***********************************************
C*** PARAMETERS
C***********************************************
a=1		! BLOCK EDGE LENGTH
r=1.2*a/2	! SPHERE RADIUS
l_legs=a/2	! LENGTH OF LEGS


C***********************************************
C*** CREATE GEOMETRY
C***********************************************
/prep7		! ENTER THE PREPROCESSOR

bloc,-a/2,a/2,-a/2,a/2,-a/2,a/2	! STEP 1: CREATE BLOCK

/ann,dele	! TELL THE USER WHAT WE DID
/tla,-0.50,0.90,START BY CREATING A BLOCK
vplo
/wait,3

sphe,,r				! STEP 2: CREATE SPHERE

/ann,dele	! TELL THE USER WHAT WE DID
/tla,-0.50,0.90,NEXT, CREATE A SPHERE TO SUBTRACT FROM THE BLOCK
vplo
/wait,3

vsbv,1,2			! STEP 3: SUBTRACT SPHERE FROM BLOCK

/ann,dele	! TELL THE USER WHAT WE DID
/tla,-0.50,0.90,SUBTRACT THE SPHERE FROM THE BLOCK
vplo
/wait,3

vsbw,all			! STEP 4: SLICE THE RESULTING VOLUME WITH THE WORKPLANE

/ann,dele	! TELL THE USER WHAT WE DID
/tla,-0.50,0.90,SLICE THE VOLUME WITH THE WORKPLANE
vplo
/wait,3

vsel,r,loc,z,-a,0		! STEP 5: SELECT THE VOLUME BELOW THE WORKPLANE, AND...
vdel,all,,,1			! DELETE THIS VOLUME AND ALL THE ENTITIES USED IN ITS CONSTRUCTION

alls
/ann,dele	! TELL THE USER WHAT WE DID
/tla,-0.50,0.90,DELETE THE VOLUME BENEATH THE WORKPLANE
vplo
/wait,3

asel,r,loc,z			! RESELECT THE AREAS AT z=0
vext,all,,,0,0,-l_legs		! EXTRUDE THESE AREAS BY DISTANCE z=-l_legs TO CREATE LEGS

/ann,dele	! TELL THE USER WHAT WE DID
/tla,-0.50,0.90,EXTRUDE THE AREAS AT Z=0 TO CREATE THE LEGS
alls				! ENSURE ALL ENTITIES ARE SELECTED
vplo				! PLOT THE RESULTING VOLUMES

/ann,dele


fini
/cle

/vie,1,1,1,3
/esha,1


C***********************************************
C*** PARAMETERS
C***********************************************
k_complete=0

w=0.10		! OVERALL WIDTH
h=0.20		! OVERALL HEIGHT

bevel=30	! BEVEL ANGLE

r_radius=0.05	! RADIUSED CORNER

x_fillet=w/4	! FILLET X COORDINATE
r_fillet=w/2	! FILLET RADIUS

x_hole=0.40*w	! HOLE X COORDINATE
y_hole=0.45*h	! HOLE Y COORDINATE
r_hole=w/4	! HOLE RADIUS

t=0.005		! PLATE THICKNESS

esz=w/20	! ELEMENT SIZE

E=2e11		! ELASTIC MODULUS
nu=0.3		! POISSON'S

F=-10000	! LOAD


C***********************************************
C*** GEOMETRY
C***********************************************
/prep7

*afun,deg

k,1			! CREATE KEYPOINTS
k,2,w
k,3,w,h-w/cos(bevel)
k,4,,h

l,1,2			! CREATE LINES
l,2,3
l,3,4
l,4,1

lfil,2,3,r_radius	! RADIUSED CORNER

al,all			! CREATE AN AREA FROM ALL LINES

wpof,x_fillet		! POSITION WORKPLANE FOR FILLET
pcirc,r_fillet		! CREATE FILLET

asba,1,2		! BOOLEAN SUBTRACTION

numc,area		! COMPRESS AREA NUMBERS

wpcs,-1,0		! POSTION WORKPLANE AT HOLE CENTER
wpof,x_hole,y_hole
pcirc,r_hole		! CREATE HOLE

asba,1,2		! BOOLEAN SUBTRACTION

aplo


C***********************************************
C*** ATTRIBUTES, MESH
C***********************************************
et,1,183
mp,ex,1,E
mp,nuxy,1,nu

esiz,esz
ames,all

eplo


C***********************************************
C*** LOADS,BCs
C***********************************************
nsel,s,loc,x		! CONSTRAIN BASE
d,all,all

nsel,s,loc,y		! APPLY LOAD
cp,1,uy,all
f,ndnext(0),fy,F

alls			! PLOT ELEMENTS w/SYMBOLS SHOWN
/pbc,u,,1
/pbc,cp,,1
/pbc,f,,1
eplo



*if,k_complete,eq,1,then

keyo,1,3,3
r,1,t

fini


C***********************************************
C*** SOLVE
C***********************************************
/solu
alls
solv
fini


C***********************************************
C*** POST PROCESS
C***********************************************
/post1

/pbc,u,,1
/pbc,cp,,1
/pbc,f,,1

plns,s,eqv	! PLOT EQUIV STRESS WITH SYMBOLS SHOWN

*endif



























fini
/cle

/vie,1,1,-2,1
/vup,1,z
/pnu,mat,1
/num,1
/psy,csys,1


C****************************************************
C*** PARAMETERS
C****************************************************
r1=0.020	! TUBE INNER RADIUS
r2=0.025	! TUBE OUTER RADIUS
l=0.250		! TUBE LENGTH
n_tubes=3	! NUMBER OF TUBES
r_major=0.050	! MAJOR RADIUS UPON WHICH TUBE CENTERLINES RESIDE

a_plates=2*(r_major+2.5*r2)	! END PLATE EDGE LENGTH
t_plates=r2-r1			! END PLATE THICKNESS

r3=r2+t_plates	! FILLET WELD OUTER RADIUS

esz=0.9*(r2-r1)	! MESH SIZE

E=2e11		! ELASTIC MODULUS
nu=0.3		! POISSON'S

f_x=2500	! X COMPONENT FORCE ON TOP PLATE
f_y=1000	! Y COMPONENT FORCE ON TOP PLATE


C****************************************************
C*** CYLINDRICAL COORDINATE SYSTEMS (ONE FOR EACH TUBE)
C****************************************************
*do,i,1,n_tubes		! LOOP OVER NUMBER OF TUBES
 wpcs,-1,0		! PLACE WORKPLANE AT GLOBAL ORIGIN
 wpro,(i-1)*360/n_tubes	! ROTATE WORKPLANE SO ITS X AXIS POINTS TOWARD TUBE i
 wpof,r_major		! OFFSET THE WORKPLANE DOWN ITS X AXIS BY r_major
 cswp,10+i,1		! CREATE CYLINDRICAL COORDINATE SYSTEM #10+i ON TUBE i CENTERLINE
*enddo			! END DO LOOP

csys
wpcs,-1,0
wpst,,,,,,,,0


C****************************************************
C*** GEOMETRY
C****************************************************
/prep7

wpcs,-1,0				! ENSURE WORKPLANE IS AT GLOBAL ORIGIN
wpof,r_major				! OFFSET WORKPLANE ALONG ITS X AXIS BY r_major

cyli,r1,r2,0,l,0,90			! 90 DEGREE SECTOR OF FIRST CYLINDER

cone,r3,r2,t_plates,2*t_plates,0,90	! WELD FILLETS
cone,r2,r3,l-2*t_plates,l-t_plates,0,90

cyli,r2,r3,0,t_plates,0,90		! TO SUBDIVIDE PLATES: 90 DEGREE SECTOR UNDER BOTTOM WELD
cyli,r2,r3,l-t_plates,l,0,90		! 90 DEGREE SECTOR ABOVE TOP WELD
cyli,r1,r2,0,t_plates,0,90		! 90 DEGREE SECTOR OF BOTTOM END OF FIRST CYLINDER
cyli,r1,r2,l-t_plates,l,0,90		! 90 DEGREE SECTOR OF TOP END OF FIRST CYLINDER

vovl,all
vglu,all

cm,scrap1_v,volu			! FOR UPCOMING BOOLEAN

vsel,none
cyli,,r1,0,l,0,90
cm,scrap2_v,volu

alls					! BOOLEAN SUBTRACTION
cmse,all
vsbv,scrap1_v,scrap2_v

cswp,11,1				! LOCAL CYLINDRICAL COORDINATE SYSTEM #11
vgen,4,all,,,0,90,0			! COPY 90 DEGREE SECTOR, 4 IN TOTAL, TO CREATE FULL CYLINDER
csys,1					! ACTIVATE GLOBAL CYLINDRICAL COORDINATE SYSTEM
vgen,n_tubes,all,,,0,360/n_tubes,0	! COPY FIRST FULL CYLINDER, n_tubes IN TOTAL, UNIFORMLY DISTRIBUTED AROUND Z AXIS

numm,kp					! MERGE COINCIDENT KEYPOINTS TO JOIN 4 90 DEGREE SECTORS

wpcs,-1,0				! END PLATES
bloc,-a_plates/2,a_plates/2,-a_plates/2,a_plates/2,,t_plates
wpof,,,l
bloc,-a_plates/2,a_plates/2,-a_plates/2,a_plates/2,,-t_plates

vovl,all				! BOOLEAN: OVERLAP ALL VOLUMES

vplo


C****************************************************
C*** ATTRIBUTES, MESH
C****************************************************
etco,set

et,1,185		! ELEMENT TYPE
mp,ex,1,E		! MATERIAL PROPERTIES
mp,nuxy,1,nu

esiz,esz		! SET ELEMENT SIZE
!vswe,all		! SWEEP MESH ALL VOLUMES


C****************************************************
C*** BCs
C****************************************************
csys			! FIX OUTER PERIMETER OF BOTTOM PLATE
vsel,s,loc,z,0,t_plates
alls,belo,volu
asel,r,ext
asel,u,loc,z
asel,u,loc,z,t_plates
da,all,all

csys			! COMPONENT COMPRISING PERIMETER AREAS OF UPPER PLATE
vsel,s,loc,z,l,l-t_plates
alls,belo,volu
asel,r,ext
asel,u,loc,z,l
asel,u,loc,z,l-t_plates
cm,prmtr_a,area

cmse,s,prmtr_a		! FX APPLIED AS A PRESSURE ON UPPER PLATE EDGE
asel,r,loc,x,a_plates/2
asum
*get,area_edge,area,arnext(0),area
sfa,all,,pres,f_x/area_edge

cmse,s,prmtr_a		! FY APPLIED AS A PRESSURE ON UPPER PLATE EDGE
asel,r,loc,y,-a_plates/2
sfa,all,,pres,f_y/area_edge

fini


C****************************************************
C*** MACRO THAT SELECTS WELDS
C****************************************************
*create,select_welds,mac	! CREATE MACRO TO SELECT WELDS

vsel,none		! UNSELECT ALL VOLUMES

*do,i,1,n_tubes		! LOOP OVER TUBES
 csys,10+i		! ACTIVATE TUBE #i CYLINDRICAL COORDINATE SYSTEM
 ksel,s,loc,x,r2,r3	! SELECT KEYPOINTS HAVING RADIAL COORDINATE r2 < r < r3
 ksel,u,loc,z		! UNSELECT KEYPOINTS AT z=0
 ksel,u,loc,z,l		! UNSELECT KEYPOINTS AT z=l
 lslk,s,1		! SELECT LINES THAT HAVE BOTH KEYPOINTS SELECTED
 asll,s,1		! SELECT AREAS THAT HAVE ALL LINES SELECTED
 vsla,a,1		! ADD VOLUMES HAVING ALL BOUNDING AREAS SELECTED TO SELECTED SET
*enddo

alls,belo,volu		! SELECT EVERYTHING BELOW SELECTED VOLUMES
/rep			! REPLOT

*end			! END OF MACRO CREATION


C****************************************************
C*** MACRO THAT SHOWS ESYS SYMBOLS
C****************************************************
*create,show_esys,mac	! CREATE MACRO TO SHOW ESYS SYMBOLS

/typ,1,0	! NON HIDDEN DISPLAY
/edg,1,1	! ELEMENT EDGES SUPPRESSED IN ELEMENT PLOTS
/dev,vect,1	! USE VECTOR MODE ("WIRE FRAME")
/psy,esys,1	! TURN ON ESYS SYMBOLS
eplo		! PLOT ELEMENTS

*end


C****************************************************
C*** MACRO THAT TURNS OFF ESYS SYMBOLS
C****************************************************
*create,hide_esys,mac	! CREATE MACRO TO SHOW ESYS SYMBOLS

/typ,1		! DEFAULT HIDDEN DISPLAY
/edg,1		! DEFAULT ELEMENT EDGES SHOWN IN ELEMENT PLOTS
/dev,vect,0	! DEFAULT RASTER FILL DISPLAY MODE
/psy,esys,0	! TURN OFF ESYS SYMBOLS
eplo		! PLOT ELEMENTS

*end


C****************************************************
C*** TOOLBAR BUTTONS THAT CALL MACROS
C****************************************************

*abbr,welds,select_welds	! CREATE AN "ABBREVIATION": "welds" = "select_welds"
*abbr,esys_on,show_esys		! CREATE AN "ABBREVIATION": "esys_on" = "show_esys"
*abbr,esys_off,hide_esys	! CREATE AN "ABBREVIATION": "esys_off" = "hide_esys"

abbs				! SAVE ABBREVIATIONS TO jobname.abbr
abbr				! "RESUME" ABBREVIATIONS - THIS CREATES THE TOOLBAR BUTTON


alls
vplo

/eof


C****************************************************
C*** SOLVE
C****************************************************
/solu
alls
save
solv
fini

wpst,,,,,,,,0


C****************************************************
C*** POST PROCESS
C****************************************************
/post1
plns,s,eqv


/eof


Y11=4.9e10	! ORTHOTROPIC MATERIAL PROPERTY DATA: RADIAL STIFFNESS
Y22=6.2e10	! ORTHOTROPIC MATERIAL PROPERTY DATA: HOOP STIFFNESS
Y33=4.9e10	! ORTHOTROPIC MATERIAL PROPERTY DATA: AXIAL STIFFNESS
nu=0.31		! POISSON'S FOR ALL 3 COMPONENTS
G=5.4836e10	! SHEAR MODULUS FOR ALL 3 COMPONENTS

mp,ex,2,Y11	! DEFINE 3 COMPONENTS OF ELASTIC MODULUS
mp,ey,2,Y22
mp,ez,2,Y33

mp,nuxy,2,nu	! DEFINE 3 POISON'S RATIOS
mp,nuyz,2,nu
mp,nuxz,2,nu

mp,gxy,2,G	! DEFINE 3 SHEAR MODULI
mp,gyz,2,G
mp,gxz,2,G






vsel,s,mat,,2
alls,belo,volu
eplo















































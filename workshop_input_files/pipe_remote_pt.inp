fini
/cle

/file,pipe_remote_pt

/vie,1,1,1,50
/pnu,type,1
/num,1
/tri,lbot
!/psy,dot,10

/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  


C******************************
C*** PARAMETERS
C******************************
pi=acos(-1)

l=2		! PIPE LENGTH
r1=0.10		! PIPE INNER RADIUS
r2=0.12		! PIPE OUTER RADIUS

esz=(r2-r1)/1.1	! ELEMENT SIZE
div_z=20

E=2e11/3	! ELASTIC MODULUS
nu=0.3		! POISSON'S RATIO

x_remote=0	! "REMOTE POINT" LOCATION
y_remote=0
z_remote=l


C******************************
C*** PIPE MODEL
C******************************
/prep7

etcon,set

cyli,r1,r2,0,l,0,90	! PIPE GEOMETRY
cyli,r1,r2,0,l,90,180
cyli,r1,r2,0,l,180,270
cyli,r1,r2,0,l,270,360
numm,kp

et,1,185			! PIPE ATTRIBUTES
mp,ex,1,E
mp,nuxy,1,nu

esiz,esz
lsel,u,loc,z
lsel,u,loc,z,l
lesi,all,,,div_z
vmes,all			! PIPE MESH


C******************************
C*** PILOT NODE FOR FORCE-BASED MPC CONTACT
C******************************

alls		! HIGHEST NODE # IN MODEL
*get,nmax,node,,num,max

n,nmax+1,x_remote,y_remote,z_remote	! CREATE NEW (PILOT) NODE

fini


C******************************
C*** BOUNDARY CONDITIONS
C******************************
/solu

nsel,s,loc,z			! BEAM CONSTRAINTS
d,all,all


C******************************
C*** LOAD STEP OPTIONS
C******************************
pred,off	! TURN OFF PREDICTOR (DESTABILIZES, PREVENT CONVERGENCE)

nlge,on		! ACTIVATE NONLINEAR GEOMETRY EFFECTS

outr,all,all	! SAVE RESULTS FOR EACH SUBSTEP

/gty,1,node,1	! DISPLAY MODEL (ELEMENTS AND NODES)
/gty,1,volu,0
/gty,1,area,0
/gty,1,line,0
/gty,1,keyp,0
/gty,1,elem,1
esel,all
eplo
/use
nsel,s,node,,nmax+1
/psy,dot,10

gplo


C*******************************************************************
C*** CREATE MACRO FILE TO FACILITATE REMOTE PT CREATION
C*** USING MPC CONTACT w/PILOT NODE
C*******************************************************************

*create,rmt_pt,mac

/pmacro

gplo


C*******************************************************************
C*** CREATE MPC CONTACT w/PILOT NODE
C*******************************************************************

*get,etmax,etype,,num,max
*get,mpmax,mat,,num,max
*get,rmax,real,,num,max
*get,secmax,secp,,num,max
attrmax=max(etmax,max(mpmax,max(secmax,rmax)))


C*******************************************************************
C*** DEFINE CONTACT ATTRIBUTES
C*******************************************************************

et,attrmax+1,174	! CONTACT ELEMENT TYPE (ON BEAM TIP)
keyo,attrmax+1,4,1	! FORCE DISTRIBUTED
keyo,attrmax+1,2,2	! MPC
keyo,attrmax+1,12,5	! BONDED

et,attrmax+2,170	! TARGET ELEMENT TYPE (PILOT NODE)
keyo,attrmax+2,2,1	! USER SPECIFIED PILOT NODE CONSTRAINT
keyo,attrmax+2,5,3	! SHELL-SOLID

tshap,pilot	! TARGET SHAPE (PILOT NODE)


C*******************************************************************
C*** PROMPT USER TO SELECT NODE TO SERVE AS REMOTE POINT
C*******************************************************************

*msg,ui
Pick remote point node
nsel,s,p

cm,pilot_n,node

real,attrmax+1

type,attrmax+2		! DEFINE TARGET PILOT ELEMENT (REMOTE POINT)
nd1=ndnext(0)
e,nd1


C*******************************************************************
C*** PROMPT USER TO SELECT AREA(S) TO BOND TO PILOT NODE
C*******************************************************************
*msg,ui
Pick surface(s) controlled by remote point

asel,s,p
nsla,s,1
cm,contact_n,node
esln

type,attrmax+1		! OVERLAY BEAM TIP WITH CONTACT ELEMENTS
esurf


C*******************************************************************
C*** DETERMINE PINBALL
C*******************************************************************

cmse,s,contact_n
*get,nnds,node,,count

nd=0
pinball=0
*do,i,1,nnds
 cmse,s,contact_n
 nd2=ndnext(nd)
 cmse,a,pilot_n
 pinball=max(pinball,distnd(nd1,nd2))
*enddo

r,attrmax+1,,,,,,2*pinball	! PINBALL

alls

*end


C*******************************************************************
C*** CREATE TOOLBAR BUTTON TO INVOKE REMOTE POINT MACRO
C*******************************************************************

*abbr,rmt_pt,rmt_pt
abbs
abbr

fini
/prep7

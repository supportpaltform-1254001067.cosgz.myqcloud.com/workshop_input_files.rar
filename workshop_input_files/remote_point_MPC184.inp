fini
/cle

/vup,1,z
/vie,1,3,-2,1
/pnu,type,1
/num,1
/tri,rbot

/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  


C******************************
C*** PARAMETERS
C******************************
k_complete=0

pi=acos(-1)

l=0.125		! BEAM LENGTH
w=0.010		! BEAM WIDTH
t=0.0015	! BEAM THICKNESS

r_holes=w/4	! HOLE RADIUS
n_holes=5	! NUMBER OF UNIFORMLY SPACED HOLES

esz=t/2		! ELEMENT SIZE

E=2e11/3	! ELASTIC MODULUS
nu=0.3		! POISSON'S RATIO

r_remote=-l/2	! "REMOTE POINT" LOCATION
UZ_remote=-l/3	! IMPOSED REMOTE POINT DISPLACEMENT
ROTX_remote=45	! IMPOSED REMOTE POINT ROTATION


C******************************
C*** BEAM MODEL
C******************************
/prep7

wpcs,-1,0
bloc,,l,-w/2,w/2,-t/2,t/2	! BEAM GEOMETRY
cm,scrap1_v,volu

vsel,none			! HOLES IN BEAM
wpcs,-1,0
wpof,l/(n_holes+1)
cyli,,r_holes,-t/2,t/2
vgen,n_holes,all,,,l/(n_holes+1)
cm,scrap2_v,volu

alls				! BOOLEAN: SUBTRACT HOLES FROM BEAM
cmsel,all
vsbv,scrap1_v,scrap2_v


etcon,set

et,1,185			! BEAM ATTRIBUTES
mp,ex,1,E
mp,nuxy,1,nu

esiz,esz
vswe,all			! BEAM MESH



C******************************
C*** BOUNDARY CONDITIONS
C******************************
nsel,s,loc,x			! BEAM CONSTRAINTS
d,all,all

nlge,on
outr,all,all

alls
eplo
/wait,1.5



*if,k_complete,eq,1,then



C******************************
C*** MPC CONTACT w/PILOT NODE
C******************************
alls
*get,nmax,node,,num,maxd	! HIGHEST NODE # IN MODEL

n,nmax+1,l,r_remote		! CREATE NEW ("REMOTE POINT") NODE


C******************************
C*** MPC184 RIGID LINKS
C******************************
et,2,184,1,1		! ELEMENT TYPE #2: MPC184 RIGID BEAM, LAGRANGE MULTIPLIER

type,2			! SET TYPE ATTRIBUTE POINTER TO TYPE #2

asel,s,loc,x,l		! SELECT BEAM TIP SURFACE
nsla,s,1		! SELECT BEAM TIP NODES
cm,tip_n,node		! NAME THESE NODES "tip_n"
*get,nnds,node,,count	! nnds = # OF NODES ON BEAM TIP

nd=0			! INITIALIZE NODE NUMBER
*do,i,1,nnds		! LOOP OVER # OF BEAM TIP NODES
 cmse,s,tip_n		! SELECT BEAM TIP NODES
 nd=ndnext(nd)		! nd = NEXT HIGHEST NODE NUMBER ON BEAM TIP
 nsel,a,node,,nmax+1	! ADD REMOTE POINT NODE TO SELECTED SET OF NODES
 e,nmax+1,nd		! CREATE MPC184 BEAM BETWEEN REMOTE POINT NODE AND NODE ON BEAM TIP
*enddo			! END DO LOOP

fini

wpst,,,,,,,,0
alls
eplo
/wait,1.5


C******************************
C*** SOLVE
C******************************
/solu
alls
d,nmax+1,rotx,pi/4	! IMPOSE ROTATION AT REMOTE POINT NODE
solv			! SOLVE
fini


C******************************
C*** POST PROCESS
C******************************
/post1

/pbc,u,,1
/pbc,rot,,1
/hbc,1,1
plns,s,eqv		! CONTOUR EQUIVALENT STRESS (SEQV)
/user,1
antime,24,.1,,1,2	! ANIMATE SEQV CONTOUR

*endif




































/eof





alls
gplo

*abbr,rmt_pt,rmt_pt
abbs
abbr


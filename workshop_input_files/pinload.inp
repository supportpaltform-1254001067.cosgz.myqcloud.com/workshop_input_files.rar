fini
/cle

/vie,1,1,1,1

/pnu,type,1
/num,1

/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  

/sys,del file*.png


C*********************************************************
C*** PARAMETERS
C*********************************************************
k_complete=0

pi=acos(-1)

l=0.100		! PLATE LENGTH
w=0.025		! PLATE WIDTH
t=0.001		! PLATE THICKNESS
r=0.005		! HOLE RADIUS

y_hole=3*r	! Y LOCATION OF HOLE

esz=(pi/2)*r/6	! MESH SIZE

E=2e11		! ELASTIC MODULUS
nu=0.3		! POISSON'S

F_pin=800	! NET PIN FORCE



C*********************************************************
C*** GEOMETRY
C*********************************************************

/prep7

wpcs,-1,0		! PLATE
bloc,-w/2,w/2,,l,,t

wpcs,-1,0		! HOLE
wpof,,y_hole
cswp,11,1
cyli,,r,,t

vsbv,1,2		! BOOLEAN SUBTRACTION

vplo


C*********************************************************
C*** ATTRIBUTES,MESH
C*********************************************************
etcon,set

et,1,186
mp,ex,1,E
mp,nuxy,1,nu

esiz,esz
vswe,all


C*********************************************************
C*** FIX TOP EDGE OF PLATE
C*********************************************************
csys
nsel,s,loc,y,l
d,all,all


C*********************************************************
C*** COMPONENT NAME FOR HOLE NODES
C*********************************************************
csys,11
nsel,s,loc,x,r
cm,hole_n,node

alls		! PLOT MODEL FOR USER
/pbc,u,,1
eplo


*if,k_complete,eq,1,then

C*********************************************************
C*** SURF154 ATTRIBUTES, MESH
C*********************************************************
et,2,154	! ELEMENT TYPE 2: SURF154
keyo,2,11,0	! SCALE PRESSURE BY PROJECTED AREA, INCLUDE TANGENTIAL COMPONENT
keyo,2,12,1	! PRESSURE=0 IF FACE NORMAL dot FORCE DIRECTION > 0

type,2		! ELEMENT TYPE POINTER: CREATE TYPE,2 (SURF154) ELEMENTS

cmse,s,hole_n	! SELECT HOLE NODES
esurf		! CREATE SURF154 ELEMENTS


C*********************************************************
C*** APPLY PRESSURE TO SURF154
C*********************************************************
esel,s,type,,2				! SELECT SURF154 ELEMENTS
sfe,all,5,pres,,F_pin/(2*r*t),0,-1,0	! APPLY PRESSURE TO FACE 5 ACTING IN (0,-1,0) DIRECTION

alls			! IMAGE SHOWING PRESSURE DISTRIBUTION/DIRECTION
/psf,pres,,2
eplo
/sho,png $eplo $/sho,close $/wait,1.5


C*********************************************************
C*** SOLVE
C*********************************************************
fini
/solu
alls
solv
fini


C*********************************************************
C*** POST PROCESS
C*********************************************************
/post1

plns,u,y	! CONTOUR UY
/sho,png $plns,u,y $/sho,close $/wait,1.5

prrs		! CHECK NET REACTION FORCE

*endif



/eof








fini
/cle

/vie,1,3,2,1
/vup,1,z

/RGB,INDEX,100,100,100, 0	! WHITE BACKGROUND 
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  


C********************************************************
C*** PARAMETERS (MKS UNITS)
C********************************************************
k_complete=1

h_beam=0.250	! I BEAM SECTION HEIGHT
w_beam=0.150	! I BEAM SECTION WIDTH
t_flange=0.025	! I BEAM FLANGE THICKNESS
t_web=0.010	! I BEAM WEB THICKNESS

l_beam=5	! I BEAM LENGTH

nx=3		! NUMBER OF BEAMS IN X DIRECTION
dx=3		! BEAM SPACING IN X DIRECTION

ny=2		! NUMBER OF BEAMS IN Y DIRECTION
dy=2		! BEAM SPACING IN Y DIRECTION

t_plate=0.025		! THICKNESS OF PLATE AT TOP OF I BEAMS
d_extnd_plate=0.25	! DISTANCE PLATE EXTENDS BEYOND I BEAM COLUMNS

esz1=0.25*min(h_beam,w_beam)	! BEAM CROSS SECTION MESH SIZE
divz=10				! # OF DIVISIONS ALONG BEAM LENGTH
spcz=-3				! MESH SPACING RATIO ALONG BEAM LENGTH

esz2=max(h_beam,w_beam)		! PLATE MESH SIZE FAR FROM WHERE BEAMS ATTACH TO IT

E=2e11		! ELASTIC MODULUS
nu=0.3		! POISSON'S
dnsty=7800	! DENSITY

nmodes=3	! FOR MODAL ANALYSIS: # OF MODES TO CALCULATE

dx_columns=(nx-1)*dx	! NUMBER OF COLUMNS IN X DIRECTION
dy_columns=(ny-1)*dy	! NUMBER OF COLUMNS IN Y DIRECTION

acel_y=1		! FOR MSUP HARMONIC: ACCELERATION IN Y DIRECTION
nfreqs=250		! NUMBER OF FREQUENCIES OVER FREQUENCY RANGE
zeta=0.05		! DIMENSIONLESS DAMPING RATIO

Q_theory=1/(2*zeta)	! EXPECTED Q FACTOR


C********************************************************
C*** MODEL: CREATE I BEAMS
C********************************************************
/prep7

etcon,set

rect,-h_beam/2,h_beam/2,-t_web/2,t_web/2		! WEB CROSS SECTION
rect,-h_beam/2,-(h_beam/2-t_flange),-w_beam/2,w_beam/2	! FLANGE CROSS SECTION
rect,h_beam/2,(h_beam/2-t_flange),-w_beam/2,w_beam/2	! FLANGE CROSS SECTION
aovl,all

et,200,200,6			! MESH BEAM CROSS SECTION						
esiz,esz1
msha,0
ames,all

et,1,185			! SOLID ELEMENT ATTRIBUTES
mp,ex,1,E
mp,nuxy,1,nu
mp,dens,1,dnsty

exto,esiz,divz,spcz		! EXTRUDE MESHED CROSS SECTION INTO MESHED BEAM
vext,all,,,0,0,l_beam

vgen,2,all,,,-dx_columns/2,-dy_columns/2,0,,,1	! CREATE COLUMNS OF I BEAMS
vgen,nx,all,,,dx
vgen,ny,all,,,,dy

eplo


C********************************************************
C*** MODEL: CREATE PLATE
C********************************************************
wpcs,-1,0		! CREATE AREA (PLATE BOTTOM SURFACE) AT TOP OF I BEAMS
wpof,,,l_beam
rect,-(dx_columns/2+h_beam/2+d_extnd_plate),(dx_columns/2+h_beam/2+d_extnd_plate),-(dy_columns/2+w_beam/2+d_extnd_plate),(dy_columns/2+w_beam/2+d_extnd_plate),,t_plate

aovl,all		! OVERLAP AREAS AT TOP OF I BEAMS	

asel,r,loc,z,l_beam	! LOCAL MESH REFINEMENT WHERE BEAMS JOINT PLATE
lsel,u,ext
ksll,r
kesi,all,esz1

esiz,esz2		! LARGER MESH SIZE ELSEWHERE ON PLATE
alls,belo,area

ames,all		! MESH LOWER SURFACE OF PLATE w/MESH200's

exto,esiz,1		! EXTRUDE MESHED SURFACE INTO MESHED VOLUME
vext,all,,,0,0,t_plate

alls
eplo


C********************************************************
C*** BC's
C********************************************************
nsel,s,loc,z
d,all,all

fini

alls
wpst,,,,,,,,0


C******************************************************************************
C*** CREATE MACRO TO CALCULATE Q FROM A COMPLEX VARIABLE IN POST26
C******************************************************************************
*cre,Q_factor,mac

C******************************************************************************
C******************************************************************************
C*** MACRO FILE Q_factor.mac CALCULATES Q FACTOR FROM A COMPLEX VARIABLE
C*** IN POST26. THE FIRST FREQUENCY OF THE VARIABLE SHOULD BE LOW ENOUGH TO
C*** HAVE NEGLIGIBLE DYNAMIC AMPLIFICATION (I.E., STEADY STATE RESPONSE)
C*** VARIABLE NUMBERS HIGHER THAN THAT USED IN THE ASSESSMENT WILL BE OVERWRITTEN.
C******************************************************************************
C******************************************************************************


C******************************************************************************
C*** PROMPT USER FOR POST26 VARIABLE NUMBER TO USE FOR Q FACTOR ASSESSMENT
C******************************************************************************
*ask,varnum,variable number for Q factor assessment,2


C******************************************************************************
C*** CREATE SRSS OF VARIABLE
C******************************************************************************
realvar,varnum+1,2,,,realpart			! REAL PART
imagin,varnum+2,2,,,imagpart			! IMAGINARY PART
prod,varnum+1,varnum+1,varnum+1,,realsqrd	! REAL PART SQUARED
prod,varnum+2,varnum+2,varnum+2,,imagsqrd	! IMAGINARY PART SQUARED
add,varnum+1,varnum+1,varnum+2,,magsqrd		! SUM OF SQUARES
sqrt,varnum+1,varnum+1,,,magntd			! SQUARE ROOT OF SUM OF SQUARES = MAGNITUDE
vardel,varnum+2					! DELETE UNEEDED VARIABLE varnum+2


C******************************************************************************
C*** DETERMINE DYNAMIC AMPLIFICATION (Q)
C******************************************************************************
*get,ss,vari,varnum+1,rset,1		! ~ STATIC RESPONSE AT FIRST SOLVED FREQUENCY
*get,peak,vari,varnum+1,extr,vmax	! MAGNITUDE AT PEAK
q_calc=peak/ss				! Q = PEAK RESPONSE/STEADY STATE RESPONSE


C******************************************************************************
C*** ANNOTATED PLOT OF MAGNITUDE OF RESPONSE
C******************************************************************************
/ann,dele
/tla,0,0.90,Q Factor = %q_calc%
/tla,-0.45,0.85,(Ratio of Peak Response/Amplitude @ First Freq)
/axl,x,Frequency
/axl,y,Magnitude of Variable #%varnum%
plva,3

/ann,dele		! CLEAN-UP: DELETE ANNOTATION
vardel,3		! CLEAN-UP: DELETE VARIABLE varnum+1

*end


C******************************************************************************
C*** DETERMINE DYNAMIC AMPLIFICATION (Q)
C******************************************************************************
*abbr,Q_factor,Q_factor
abbs
abbr


C********************************************************
C*** MODAL ANALYSIS
C********************************************************

/solu

anty,modal		! MODAL ANALYSIS
modopt,lanb,nmodes	! NUMBER OF MODES TO EXTRACT
mxpand,all,,,yes	! EXPAND ALL MODES, OUTPUT ELEMENT RESULTS (STRESSES)

alls
save
solve
fini

*get,f1,mode,1,freq	! f1 = FIRST NATURAL FREQUENCY


*if,k_complete,eq,1,then

C********************************************************
C*** MSUP HARMONIC
C********************************************************
/solu

anty,harm		! HARMONIC RESPONSE ANALYSIS

hropt,msup		! USING THE MODE SUPERPOSITION METHOD
harf,0,nint(2*f1)	! FREQUENCY RANGE FOR HARMONIC SWEEP
nsub,nfreqs		! NUMBER OF FREQUENCIES OVER FREQUENCY RANGE

dmpr,zeta		! DIMENSIONLESS DAMPING RATIO

acel,,acel_y		! EXCITATION: LATERAL BASE ACCELERATION

kbc,1			! LOADS STEP APPLIED TO FULL VALUE FOR ALL FREQUENCIES

solv			! SOLVE
fini


C********************************************************
C*** POST PROCESS REDUCED HARMONIC RESPONSE RESULTS
C********************************************************
/post26
file,,rfrq

nsol,2,node(0,0,l_beam),u,y,U_plate


C******************************************************************************
C*** CREATE SRSS OF VARIABLE
C******************************************************************************
varnum=2

realvar,varnum+1,2,,,realpart			! REAL PART
imagin,varnum+2,2,,,imagpart			! IMAGINARY PART
prod,varnum+1,varnum+1,varnum+1,,realsqrd	! REAL PART SQUARED
prod,varnum+2,varnum+2,varnum+2,,imagsqrd	! IMAGINARY PART SQUARED
add,varnum+1,varnum+1,varnum+2,,magsqrd		! SUM OF SQUARES
sqrt,varnum+1,varnum+1,,,magntd			! SQUARE ROOT OF SUM OF SQUARES = MAGNITUDE
vardel,varnum+2					! DELETE UNEEDED VARIABLE varnum+2


C******************************************************************************
C*** DETERMINE DYNAMIC AMPLIFICATION (Q)
C******************************************************************************
*get,ss,vari,varnum+1,rset,1		! ~ STATIC RESPONSE AT FIRST SOLVED FREQUENCY
*get,peak,vari,varnum+1,extr,vmax	! MAGNITUDE AT PEAK
q_calc=peak/ss				! Q = PEAK RESPONSE/STEADY STATE RESPONSE


C******************************************************************************
C*** ANNOTATED PLOT OF MAGNITUDE OF RESPONSE
C******************************************************************************
/ann,dele
/tla,-0.50,0.90,Q Factor (Ratio of Peak Response/Amplitude @ First Freq)
/tla,-0.25,0.85, Theory: %Q_theory%, Calculated: %q_calc%
/axl,x,Frequency (s^-1)				! AXIS LABELS
/axl,y,Plate Displacement (m)

plva,3						! ANNOTATED PLOT OF RESPONSE
/wait,3
vardel,3
fini


C********************************************************
C*** MSUP HARMONIC EXPANSION PASS
C*** NOTE: MUST FIRST LEAVE SOLUTION PROCESSOR, THEN RE-ENTER TO PERFORM EXPANSION PASS
C********************************************************
/solu
expa,on		! EXPANSION PASS ON
numex,all	! EXPAND ALL FREQUENCIES
solv		! PERFORM EXPANSION PASS
fini


C******************************************************************************
C*** CONTOUR PLOT AND ANIMATION OF UY
C******************************************************************************
/post1					! CONTOUR PLOT OF DISPLACEMENT AT PEAK RESPONSE FREQUENCY
set,near,,,1,f1
plns,u,y

anharm,40,.1


*endif

/eof





/solu			! ENTER THE SOLUTION PROCESSOR
anty,harm		! PERFORM A HARMONIC RESPONSE ANALYSIS
hropt,msup		! USING THE MODE SUPERPOSITION METHOD

harf,0,5		! FREQUENCY RANGE TO INVESTIGATE
nsub,250		! NUMBER OF FREQUENCY INTERVALS OVER THE RANGE
kbc,1			! LOADS SHALL BE STEP-APPLIED (NOT RAMPED!)

dmpr,0.05		! DAMPING RATIO (DIMENSIONLESS)
acel,,1			! LATERAL ACCELERATION

save
solv			! SOLVE

/post26				! ENTER THE TIME HISTORY POST PROCESSOR
file,,rfrq			! READ RESULTS FROM JOBNAME.rfrq
nsol,2,node(0,0,l_beam),u,y	! READ RESULTS AT NODE IN MIDDLE OF THE PLATE
plva,2				! PLOT THE AMPLITUDE OF THE RESPONSE VERSUS FREQUENCY

















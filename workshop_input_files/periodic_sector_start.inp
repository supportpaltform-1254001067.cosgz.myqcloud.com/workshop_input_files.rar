
fini
/cle

/vie,1,1,2,2
/vup,1,z
/hbc,1,1

/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  

/sys,del *.png


C************************************************************************
C*** PARAMETERS (MKS)
C************************************************************************
k_complete=0			! 1: COMPLETE RUN, OTHERWISE LEAVE OFF WHERE CLASS BEGINS

pi=acos(-1)

n_blades=18			! NUMBER OF FAN BLADES
thta_sector=360/n_blades	! IMPLIED NUMBER OF PERIODIC SECTORS (DO NOT EDIT)

r_hole=0.010			! RADIUS OF HOLE IN HUB (m)
r_hub=0.040			! HUB OUTER RADIUS
l_hub=0.050			! HUB LENGTH

r_end_plate=0.200		! END PLATE OUTER RADIUS
t_end_plate=0.005		! END PLATE THICKNESS

t_blade=0.002			! BLADE THICKNESS
r_lead_blade=0.165		! RADIAL COORDINATE OF BLADE LEADING EDGE
r_trail_blade=0.190		! RADIAL COORDINATE OF BLADE TRAILING EDGE
thta_blade=0.75*thta_sector	! ANGLE SUBTENDED BY BLADE (LEADING EDGE TO TRAINLING EDGE)
thta_lead_blade=-10		! BLADE LEADING EDGE ANGLE
thta_trail_blade=-45		! BLADE TRAILING EDGE ANGLE

l_overall=0.250			! FAN TOTAL LENGTH

r_opening=0.150			! RADIUS OF OPENING ON TOP END PLATE

esz=1.5*t_blade			! MESH SIZE

E=0.67e11			! EALSTIC MODULUS (N/m^2)
nu=0.3				! POISSON'S
dnsty=2600			! DENSITY (kg/m^3)

RPM=1000			! FAN SPEED (RPM)
p_blade_out=101000/10		! AERODYNAMIC PRESSURE ON OUTER SURFACE OF BLADE (N/m^2)

/title,SPEED = %RPM% RPM, BLADE PRESSURE = %p_blade_out% N/m^2


C************************************************************************
C*** GEOMETRY
C************************************************************************
/prep7

csys,1						! GLOBAL CYLINDRICAL COORDINATE SYSTEM

k,1,r_lead_blade,thta_blade/2,t_end_plate	! BLADE END POINTS
k,2,r_trail_blade,-thta_blade/2,t_end_plate

*afun,deg					! VECTORS DEFINING SLOPES AT 2 ENDS OF CURVED BLADE

xv1=cos(90+thta_lead_blade+thta_blade/2)	! LEADING EDGE CSYS,1 X COMPONENT
yv1=sin(90+thta_lead_blade+thta_blade/2)	! LEADING EDGE CSYS,1 Y COMPONENT

xv2=cos(-90-thta_trail_blade-thta_blade/2)	! TRAILING EDGE CSYS,1 X COMPONENT
yv2=sin(-90-thta_trail_blade-thta_blade/2)	! TRAILING EDGE CSYS,1 Y COMPONENT

csys						! GLOBAL CARTESIAN COORDINATE SYSTEM

l,1,2,,,xv1,yv1,0,xv2,yv2,0			! CURVED LINE (BLADE PROFILE) WITH END SLOPES (BASE OF BLADE)
lgen,2,1,,,0,0,l_overall-2*t_end_plate		! DUPLICATE LINE AT TOP OF BLADE
a,1,2,4,3					! BLADE INNER SURFACE USING CURVED LINES
cm,blade_in_a,area				! NAME BLADE INNER SURFACE
aoff,1,-t_blade					! OFFSET INNER BLADE SURFACE BY BLADE THICKNESS
cmse,u,blade_in_a
cm,blade_out_a,area				! NAME BLADE OUTER SURFACE
alls
v,1,2,4,3,5,6,7,8				! BLADE VOLUME USING CURVED SURFACES

cyli,r_hole,r_end_plate,0,t_end_plate,-thta_sector/2,thta_sector/2
cyli,r_opening,r_end_plate,l_overall,l_overall-t_end_plate,-thta_sector/2,thta_sector/2
cyli,r_hole,r_hub,0,l_hub,-thta_sector/2,thta_sector/2

vovl,all
vglu,all

/pnu,kp,1
vplo
/pnu,kp


C************************************************************************
C*** DEFINE ATTRIBUTES, MESH VOLUMES BETWEEN PERIODIC BOUNDARIES WITH TETRAHEDRA
C************************************************************************
etcon,set			! PROGRAM AUTOMATICALLY DECIDES FORMULATION

et,1,187			! 10 NODE TET
mp,ex,1,E			! ELASTIC MODULUS
mp,nuxy,1,nu			! POISSON'S
mp,dens,1,dnsty			! DENSITY


C************************************************************************
C*** MESH LOW SECTOR, COPY MESH TO HIGH SECTOR
C************************************************************************
et,200,200,5			! ELEMENT TYPE TO MESH PERIODIC BOUNDARIES

csys,1				! GLOBAL CYLINDRICAL COORDINATE SYSTEM

esiz,esz			! DECLARE MESH SIZE



*if,k_complete,eq,1,then



asel,s,loc,y,-thta_sector/2	! SELECT "LOW" PERIODIC SECTOR AREAS
cm,low_a,area			! NAME FOR THESE AREAS
ames,all			! MESH THESE AREAS

asel,s,loc,y,thta_sector/2	! SELECT "HIGH" PERIODIC SECTOR AREAS
cm,high_a,area			! NAME THESE AREAS

alls				! COPY "LOW" BOUNDARY MESH TO "HIGH" AREAS
mshcopy,area,low_a,high_a,1,0,thta_sector

alls				! PLOT MESHES OF PERIODIC BOUNDARIES
eplo
/sho,png $eplo $/sho,close $/wait,1.5


C************************************************************************
C*** DEFINE ATTRIBUTES, MESH VOLUMES BETWEEN PERIODIC BOUNDARIES WITH TETRAHEDRA
C************************************************************************
alls

vmes,all			! MESH

/expand,thta_sector,polar,full,,thta_sector	! "EXPANDED" ELEMENT PLOT
/edg,1,1
eplo
/sho,png $eplo $/sho,close $/wait,1.5


C************************************************************************
C*** PERIODIC BOUNDARY CONDITIONS (CPCYC COMMAND)
C************************************************************************
alls
cpcyc,all,,1,0,thta_sector,0


C************************************************************************
C*** ANGULAR VELOCITY, BLADE FLUID PRESSURE LOAD
C************************************************************************
omega,,,RPM*2*pi/60			! ANGULAR VELOCITY (RADIANS/s)

sfa,blade_out_a,,pres,p_blade_out	! APPLY AERODYNAMIC PRESSURE ON BLADE OUTER SURFACE

csys,1					! CONSTRAIN INNER SURFACE OF HOLE IN HUB
nsel,s,loc,x,r_hole
nrot,all
d,all,uy
d,all,uz

alls
sbct					! TRANSFER SOLID MODEL BCs TO FINITE ELEMENT MODEL
/pbc,all,1				! SHOW ALL APPLIED BCs
/psf,pres,,1				! SHOW PRESSURE SURFACE LOADS (ARROWS)
/exp					! NO EXPANSION; SHOW ONLY MODELED SECTOR
eplo					! PLOT ELEMENTS SHOWING APPLIED BC's
/sho,png $eplo $/sho,close $/wait,1.5


C************************************************************************
C*** SOLVE
C************************************************************************
/solu
alls
save
solv
fini


C************************************************************************
C*** POST PROCESS
C************************************************************************
/post1

rsys,1						! CONTOUR RADIAL DISPLACEMENT
/edg
/expand,thta_sector,polar,full,,thta_sector	! "EXPANDED" ELEMENT PLOT
plns,u,x

ancntr,10,.1					! ANIMATE PREVIOUS CONTOUR PLOT

*endif

/eof

















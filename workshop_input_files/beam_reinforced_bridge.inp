fini
/cle

/esha,1
/dsc,1,20

/vie,1,2,1,-1
/vup,1,z

/psy,dot,5



/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  


C******************************************
C*** PARAMETERS
C******************************************
k_complete=0

l=100		! BRIDGE LENGTH
w=15		! BRIDGE WIDTH

t=0.5		! DECK THICKNESS

w1=0.5		! BEAM BOTTOM FLANGE WIDTH
w2=0.5		! BEAM TOP FLANGE WIDTH
w3=1.5		! BEAM DEPTH

t1=0.10	! BOTTOM FLANGE THICKNESS
t2=0.10	! TOP FLANGE THICKNESS
t3=0.05	! WEB THICKNESS

s_beam=7.5	! BEAM SEPARATION

s_sill=l/3	! CAP SILL SEPARATION

E_beam=2e11	! BEAM ELASTIC MODULUS
nu_beam=0.30	! BEAM POISSON'S
dnsty_beam=7800	! BEAM DENSITY

E_deck=0.2e11	! DECK ELASTIC MODULUS
nu_deck=0.20	! DECK POISSON'S
dnsty_deck=5000	! DECK DENSITY

esz=l/50	! MESH SIZE



C******************************************
C*** BEAM188 LINE
C******************************************
/prep7

k,1,,-s_beam/2,-w
k,2,,s_beam/2,-w

rect,,l,-s_beam/2,s_beam/2
rect,,l,-s_beam/2,-w/2
rect,,l,s_beam/2,w/2
numm,kp
wpro,,,90
wpof,,,l/2-s_sill/2
asbw,all
wpof,,,s_sill
asbw,all

alls
/num
/pnu,kp,1
wpst,,,,,,,,0
/gty,1,line,0
/gty,1,elem,0
/gty,1,node,0
gplo
/wait,2


*if,k_complete,eq,1,then

aatt,1,,1,,1

lsel,s,loc,y,-s_beam/2
latt,2,,2,,1,,2

lsel,s,loc,y,s_beam/2
latt,2,,2,,2,,2


gplo


C******************************************
C*** ATTRIBUTES, MESH
C******************************************

et,1,181		! PLATE ATTRIBUTES

mp,ex,1,E_deck
mp,nuxy,1,nu_deck
mp,dens,1,dnsty_deck

sectyp,1,shell
secdata,t
secof,bot


et,2,188		! BEAM ATTRIBUTES

mp,ex,2,E_beam
mp,nuxy,2,nu_beam
mp,dens,2,dnsty_beam

sectyp,2,beam,i
secdata,w1,w2,w3,t1,t2,t3
secof,user

alls			! MESHING
esiz,esz
ames,all

lsel,s,mat,,2
lmes,all

alls
eplo


C******************************************
C*** CONSTRAINTS
C******************************************
lsel,s,loc,x			! FIX ENDS
lsel,a,loc,x,l
dl,all,,all


ksel,s,loc,x,l/2-s_sill/2	! VERTICAL SUPPORTS AT CAP SILLS
ksel,a,loc,x,l/2+s_sill/2
lsel,s,type,,2
ksll,r
dk,all,uz

acel,,,9.81			! GRAVITY

fini


C******************************************
C*** SOLVE
C******************************************
/solu
alls
save
solv
fini

wpst,,,,,,,,0


C******************************************
C*** POST PROCESSING
C******************************************
/post1
/pbc,u,,1
plns,u,z

*endif


fini
/cle

/vie,1,3,2,-1
/vup,1,z


C***********************************************
C*** PARAMETERS
C***********************************************
a=1		! BLOCK EDGE LENGTH
r=1.2*a/2	! SPHERE RADIUS
l_legs=a/2	! LENGTH OF LEGS


C***********************************************
C*** CREATE GEOMETRY
C***********************************************
/prep7		! ENTER THE PREPROCESSOR

bloc,-a/2,a/2,-a/2,a/2,-a/2,a/2	! STEP 1: CREATE BLOCK
sphe,,r				! STEP 2: CREATE SPHERE
vsbv,1,2			! STEP 3: SUBTRACT SPHERE FROM BLOCK
vsbw,all			! STEP 4: SLICE THE RESULTING VOLUME WITH THE WORKPLANE
vsel,r,loc,z,-a,0		! STEP 5: SELECT THE VOLUME BELOW THE WORKPLANE, AND...
vdel,all,,,1			! DELETE THIS VOLUME AND ALL THE ENTITIES USED IN ITS CONSTRUCTION

asel,r,loc,z			! RESELECT THE AREAS AT z=0
vext,all,,,0,0,-l_legs		! EXTRUDE THESE AREAS BY DISTANCE z=-l_legs TO CREATE LEGS

alls				! ENSURE ALL ENTITIES ARE SELECTED
vplo				! PLOT THE RESULTING VOLUMES



/eof


et,1,186

vcle,all

esiz,0.05



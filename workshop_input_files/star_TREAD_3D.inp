
fini
/cle

/vie,1,1,1,1
/vup,1,z
/hbc,1,1

/RGB,INDEX,100,100,100, 0   
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  


C*******************************
C*** PLATE DIMESIONS
C*******************************
k_complete=0	 ! 1: RUN WORKSHOP TO COMPLETION

l=10	! PLATE LENGTH
w=5	! PLATE WIDTH
t=0.5	! PLATE THICKNESS

E=2e11	! ELASTIC MODULUS
nu=0.3	! POISSON'S

esz=t/4	! MESH SIZE


C*******************************
C*** MODEL
C*******************************
/prep7
bloc,,L,,w,,t	! GEOMETRY

etcon,set	! ATTRIBUTES
et,1,185
mp,ex,1,E
mp,nuxy,1,nu

esiz,esz
vmes,all	! MESH

nsel,s,loc,x	! FIX ONE EDGE
d,all,all

alls
eplo

fini
/solu


*if,k_complete,eq,1,then

C*******************************
C*** READ COMMA DELIMITED DATA 
C*** FROM TEST FILE "temp_vs_xyz.txt"
C*******************************
*dim,temp_xyz,table,3,3,3,x,y,z	! DIMENSION TABLE
*tread,temp_xyz,temp_vs_xyz,txt	! READ TEMP{x,y,z} DATA INTO TABLE

alls
bf,all,temp,%temp_xyz%		! APPLY TEMPERATURES USING TABLE


alls		! CAPPED HIDDEN PLOT TO REVEAL TEMPERATURE DISTRIBUTION
/pbf,temp,,1
/typ,1,7
/cpl,1
kwpa,all
wpro,,-90
eplo

*endif



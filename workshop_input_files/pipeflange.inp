

fini
/cle

/vup,1,z			! VIEWING SPECS
/vie,1,3,3,2
/pnu,mat,1
/num,1
/dsc,1,1 

/RGB,INDEX,100,100,100, 0 	! WHITE BACKGROUND  
/RGB,INDEX, 80, 80, 80,13   
/RGB,INDEX, 60, 60, 60,14   
/RGB,INDEX, 0, 0, 0,15  


/sys,del file*.png


C*************************************************************
C*** PARAMETERS
C*************************************************************
k_complete=1		! 1: COMPLETE WORKSHOP, 0: USER DOES IT

pi=acos(-1)

ID_pipe=12				! PIPE ID
l_pipe=12				! MODELED LENGTH OF PIPE
t_pipe=1				! PIPE WALL THICKNESS

OD_flange=24				! FLANGE OD
t_flange=2				! FLANGE THICKNESS

r_fillet=1				! FILLET RADIUS

OD_gasket=ID_pipe+2*(t_pipe+r_fillet)+0.5	! OD GASKET BETWEEN FLANGES
t_gasket=0.2				! THICKNESS GASKET BETWEEN FLANGES

D_pattern=ID_pipe/2+t_pipe+OD_flange/2	! FLANGE HOLE PATTERN RADIUS
d_holes=1.5				! FLANGE HOLE DIAMETER
n_holes=12				! # OF FLANGE HOLES

d_bolt=1.25				! BOLT DIAMETER
d_bolt_head=2.5				! BOLT HEAD RADIUS
t_bolt_head=0.75			! BOLT HEAD THICKNESS

E=30e6					! ELASTIC MODULUS
nu=0.3					! POISSON'S

preload=15000				! BOLT PRELOAD
mu=0.4					! CONTACT SURFACE FRICTION COEFFICIENT

P_internal=250				! INTERNAL PRESSURE

F_axial = P_internal*pi*ID_pipe**2	! CORRESPONDING AXIAL LOAD
F_axial = F_axial/n_holes


C*************************************************************
C*** PIPE AND FLANGE GEOMETRY
C*************************************************************
/prep7

wpcs,-1,0
wpof,,,t_gasket/2

cyli,ID_pipe/2,ID_pipe/2+t_pipe,t_flange+r_fillet,l_pipe,0,180/n_holes	! CYLINDER
cyli,ID_pipe/2+t_pipe+r_fillet,OD_flange/2,0,t_flange,0,180/n_holes	! FLANGE
cyli,ID_pipe/2,ID_pipe/2+t_pipe+r_fillet,0,t_flange+r_fillet,0,180/n_holes	! WILL BECOME FILLET

vglu,all			! OVERLAP VOLUMES

cm,scrap1_v,volu		! COMPONENT NAME FOR UPCOMING BOOLEAN

vsel,none			! FILLET (TORUS)
wpcs,-1,0
wpof,,,t_flange+r_fillet+t_gasket/2
torus,0,r_fillet,ID_pipe/2+t_pipe+r_fillet

cm,scrap2_v,volu		! COMPONENT NAME FOR UPCOMING BOOLEAN

alls				! BOOLEAN: SUBTRACT TORUS TO FORM FILLET
vsbv,scrap1_v,scrap2_v

alls
cm,scrap1_v,volu		! COMPONENT NAME FOR UPCOMING BOOLEAN

vsel,none			! BOLT HOLE
wpcs,-1,0
wpof,D_pattern/2,,t_gasket/2
cyli,0,d_holes/2,0,t_flange

cm,scrap2_v,volu		! COMPONENT NAME FOR UPCOMING BOOLEAN

alls				! BOOLEAN: SUBTRACT BOLT HOLE FROM FLANGE
vsbv,scrap1_v,scrap2_v

csys				! GLOBAL XY PLANE SYMMETRY REFLECTION
vsym,z,all

csys				! SYMMETRY REFLECTION ABOUT GLOBAL Y AXIS
vsym,y,all

numm,kp				! MERGE COINCIDENT KEYPOINTS

vatt,1,1,1			! ASSIGN ATTRIBUTE NUMBERS AND NAME VOLUMES
cm,pipe_flange_v,volu


C*************************************************************
C*** GASKET
C*************************************************************
wpcs,-1,0

vsel,none
cyli,ID_pipe/2,OD_gasket/2,-t_gasket/2,t_gasket/2,-180/n_holes,180/n_holes	! GASKET BETWEEN FLANGES

vatt,3,3,3			! ASSIGN ATTRIBUTE NUMBERS AND NAME VOLUMES
cm,gasket_v,volu

alls

vplo


C*************************************************************
C*** BOLT GEOMETRY, MESH
C*************************************************************
vsel,none			! BOLT AND BOLT HEAD
wpcs,-1,0
wpof,D_pattern/2
cyli,0,d_bolt/2,0,t_gasket/2+t_flange+t_bolt_head,0,90
cyli,0,d_bolt_head/2,t_gasket/2+t_flange,t_gasket/2+t_flange+t_bolt_head,0,90
cswp,11,1
vgen,4,all,,,0,90,0
vovl,all

csys				! GLOBAL XY PLANE SYMMETRY REFLECTION
vsym,z,all

alls,belo,volu			! MERGE COINCIDENT KEYPOINTS
numm,kp

vatt,2,2,2			! ASSIGN ATTRIBUTE NUMBERS AND NAME VOLUMES
cm,bolt_v,volu

alls
vplo


C*************************************************************
C*** ATTRIBUTES, MESH
C*************************************************************
etcon,set

et,1,185	! PIPE/FLANGE ATTRIBUTES
mp,ex,1,E
mp,nuxy,1,nu

et,2,185	! BOLT ATTRIBUTES
mp,ex,2,E
mp,nuxy,2,nu

et,3,195	! GASKET ATTRIBUTES
TB,GASKET,3,1,10,COMP       ! compression curve 
TBTEMP,212
TBPT,,0.00078740157480315,7832.03941372765/25
TBPT,,0.0015748031496063,22045.7405719741/25
TBPT,,0.00236220472440945,36114.4039632997/25
TBPT,,0.00307086614173228,43511.3300762647/25
TBPT,,0.0047244094488189,53954.0492945683/25
TBPT,,0.00748031496062992,68747.9015204983/25
TBPT,,0.011259842519685,84847.0936487162/25
TBPT,,0.0140944881889764,97755.4549046748/25
TBPT,,0.017007874015748,113129.458198288/25
TBPT,,0.0198818897637795,129953.839161111/25
TB,GASKET,3,1,5,NUNL        ! unloading curve 
TBTEMP,212
TBPT,,0.00307086614173228,43511.3300762647/25
TBPT,,0.00263385826771654,3596.93661963788/25
TBPT,,0.00248425196850394,1196.56157709728/25
TBPT,,0.00212992125984252,217.556650381324/25
TBPT,,0,0
TB,GASKET,3,1,5,NUNL        ! unloading curve  2
TBTEMP,212
TBPT,,0.011259842519685,84847.0936487162/25
TBPT,,0.0103937007874016,3248.84597902777/25
TBPT,,0.0102755905511811,1305.33990228794/25
TBPT,,0.0100787401574803,217.556650381324/25
TBPT,,0,0
TB,GASKET,3,1,5,NUNL        ! unloading curve  3
TBTEMP,212
TBPT,,0.0198818897637795,129953.839161111/25
TBPT,,0.0188188976377953,4916.78029861791/25
TBPT,,0.0187007874015748,1958.00985343191/25
TBPT,,0.0184251968503937,217.556650381324/25
TBPT,,0,0

vsel,s,mat,,1,2			! MESH PIPE-FLANGE AND BOLT
vswe,all

vsel,s,mat,,3			! MESH GASKET

alls,belo,volu
asel,r,loc,z,-t_gasket/2
a1=arnext(0)
et,200,200,6
ames,all

alls,belo,volu
asel,r,loc,z,t_gasket/2
a2=arnext(0)

alls,belo,volu
imes,2,a1,a2,0,0,0,t_gasket

alls
eplo


C*************************************************************
C*** CONTACT BETWEEN GASKET AND TOP FLANGE
C*************************************************************

et,11,173	! CONTACT
keyo,11,2,1	! PURE PENALTY
keyo,11,12,1	! ROUGH

et,12,170	! TARGET

r,11

real,11
mat,11

csys		! TARGET ON FLANGE
vsel,s,mat,,1
vsel,r,loc,z,0,l_pipe
alls,belo,volu
nsel,r,loc,z,t_gasket/2

type,12
esurf

csys		! CONTACT ON GASKET
vsel,s,mat,,3
alls,belo,volu
nsel,r,loc,z,t_gasket/2

type,11
esurf


C*************************************************************
C*** CONTACT BETWEEN GASKET AND BOTTOM FLANGE
C*************************************************************

et,21,173	! CONTACT
keyo,21,2,1	! PURE PENALTY
keyo,21,12,1	! ROUGH

et,22,170	! TARGET

r,21

real,21
mat,21

csys		! TARGET ON FLANGE
vsel,s,mat,,1
vsel,r,loc,z,0,-l_pipe
alls,belo,volu
nsel,r,loc,z,-t_gasket/2

type,22
esurf

csys		! CONTACT ON GASKET
vsel,s,mat,,3
alls,belo,volu
nsel,r,loc,z,-t_gasket/2

type,21
esurf


C*************************************************************
C*** CONTACT BETWEEN UPPER BOLT HEAD AND UPPER FLANGE
C*************************************************************

et,31,173	! CONTACT
keyo,31,2,1	! PURE PENALTY

et,32,170	! TARGET

mp,mu,31,mu	! FRICTION

r,31

real,31
mat,31

csys,1		! TARGET ON FLANGE
vsel,s,mat,,1
vsel,r,loc,z,0,l_pipe
alls,belo,volu
nsel,r,loc,x,ID_pipe/2+r_fillet,OD_flange/2
nsel,r,loc,z,t_gasket/2+t_flange

type,32
esurf

csys,1		! CONTACT ON BOLT
vsel,s,mat,,2
vsel,r,loc,z,0,l_pipe
alls,belo,volu
nsel,r,loc,x,ID_pipe/2+r_fillet,OD_flange/2
nsel,r,loc,z,t_gasket/2+t_flange

type,31
esurf


C*************************************************************
C*** CONTACT BETWEEN LOWER BOLT HEAD AND LOWER FLANGE
C*************************************************************

et,41,173	! CONTACT
keyo,41,2,1	! PURE PENALTY

et,42,170	! TARGET

mp,mu,41,mu	! FRICTION

r,41

real,41
mat,41

csys,1		! TARGET ON FLANGE
vsel,s,mat,,1
vsel,r,loc,z,0,-l_pipe
alls,belo,volu
nsel,r,loc,x,ID_pipe/2+r_fillet,OD_flange/2
nsel,r,loc,z,-(t_gasket/2+t_flange)

type,42
esurf

csys,1		! CONTACT ON BOLT
vsel,s,mat,,2
vsel,r,loc,z,0,-l_pipe
alls,belo,volu
nsel,r,loc,x,ID_pipe/2+r_fillet,OD_flange/2
nsel,r,loc,z,-(t_gasket/2+t_flange)

type,41
esurf

alls
eplo
/wait,1


C*************************************************************
C*** CONSTRAINTS
C*************************************************************
csys,1

nsel,s,loc,y,180/n_holes		! SYMMETRY BCs ON SECTOR FACES
nsel,a,loc,y,-180/n_holes
nrot,all
d,all,uy

nsel,s,loc,z,-(l_pipe+t_gasket/2)	! AXIAL CONSTRAINT ON LOWERMOST PIPE EDGE
d,all,uz

vsel,s,mat,,1				! COUPLE AXIAL DISPLACEMENTS ON UPPERMOST PIPE EDGE
alls,belo,volu
nsel,r,loc,z,t_gasket/2+l_pipe
cp,1,uz,all


C*************************************************************
C*** LOAD STEP OPTIONS
C*************************************************************
/solu

autots,on
nsub,5,20,2	! RANGE # OF SUBSTEPS

cnvt,f,,1e-5

outr,all,all	! SAVE ALL CALCULATED RESULTS

alls
eplo

fini
/prep7



*if,k_complete,eq,1,then

C*************************************************************
C*** CREATE BOLT PRETENSION MESH
C*************************************************************

cmse,s,bolt_v
alls,belo,volu
psmesh,1,,,all,,0,z,0,,,,pret_e,pret_n


C*************************************************************
C*** APPLY BOLT PRELOAD
C*************************************************************
alls
sload,1,pl01,,forc,preload,1,2

fini

C*************************************************************
C*** DEFINE LS1: BOLT PRETENSION
C*************************************************************
/solu

/title,BOLT PRELOAD (%preload% lbf) ONLY

sload,1,pl01,,forc,preload,1,2	! DEFINE BOLT PRELOAD FOR LS1, LOCK FOR LS2

alls
lswrite,1			! WRITE LOAD STEP FILE 1


C*************************************************************
C*** DEFINE LS2: ADD INTERNAL PRESSURE AND AXIAL FORCE
C*************************************************************
/title,BOLT PRELOAD (%preload% lbf) + INTERNAL PRESSURE = %P_internal% psi

csys,1			! INTERNAL PRESSURE
alls
alls,belo,volu
ksel,r,loc,x,ID_pipe/2
lslk,r,1
asll,r,1
sfa,all,,pres,P_internal

nsel,s,cp,,1		! CORRESPONDING AXIAL LOAD
f,ndnext(0),fz,F_axial

alls
lswrite,2		! WRITE LOAD STEP FILE 2


C*************************************************************
C*** SOLVE LOAD STEPS 1 AND 2
C*************************************************************
alls
lssolve,1,2

fini


C*************************************************************
C*** POST PROCESS
C*************************************************************

alls
eplo
/sho,png $eplo $/sho,close $/wait,1

tbpl,gasket,3,all
/sho,png $tbpl,gasket,3,all $/sho,close $/wait,1

/post1
plns,u,z
/sho,png $plns,u,z $/sho,close $/wait,1

vsel,s,mat,,3
alls,belo,volu
plns,gks,x
/sho,png $plns,gks,x $/sho,close $/wait,1

*endif


/eof


